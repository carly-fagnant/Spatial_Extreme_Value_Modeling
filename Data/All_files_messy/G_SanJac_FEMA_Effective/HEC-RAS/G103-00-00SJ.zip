HEC-RAS study G103-00-00SJ.prj: G103-00-00SJ

--- G103-00-00SJ.g04 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,97516.01,1592.9,3052.06,210.65
BEGIN DESCRIPTION:
sj18p14
Bank Station offset =     14981
END DESCRIPTION:
XS GIS Cut Line= 6
      3218298.82    13873504.291     3213918.866    13870879.944
     3213991.382    13870373.592     3212319.972    13869744.052
     3204715.486    13869545.957     3201652.986    13868650.124
#Sta/Elev= 30
       0   39.01 2271.96   35.91 2447.59   31.78  3042.8    2.43 4385.19    4.99
 5057.31    3.15 5073.56     -.1 5118.56    -4.6 5158.56   -15.7 5398.56   -21.1
 5438.56    -3.1 5461.56    -1.7 5473.96    4.89 5552.92    7.44 6784.43    10.3
 8520.22    7.4510944.85   11.8111692.93   10.0711817.39     9.111937.05     1.7
12327.38    1.3912612.41    9.7413019.92    6.7913311.38   10.3213845.18   34.92
15522.11   34.6116761.77    41.1 17233.1   35.2517998.91   39.9618250.22    37.3
#Mann= 3 , 0 , 0
       0     .13       0 5073.56     .03       0 5461.56     .13       0
Bank Sta=5073.56,5461.56
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,94463.95,1481.36,1400.73,430.36
BEGIN DESCRIPTION:
sj17p58t
Bank Station offset =     15151
END DESCRIPTION:
XS GIS Cut Line= 6
     3221716.604    13870362.448     3216764.346    13870973.785
      3214614.94    13869700.747     3207159.542    13869576.065
     3205101.563    13869370.338     3201517.849    13868490.641
#Sta/Elev= 30
       0   39.08 3512.05   33.64 3575.41   22.17 3633.12   19.69 3777.76   30.82
 4097.27    26.3 4329.12   13.82 4410.25   16.69 4633.92     4.5 4843.84    6.59
 4906.64     1.4 5120.64   -23.3 5260.64   -18.3 5290.64   -14.3 5300.64    -4.3
 5333.64    -1.3 5358.32    8.03    5406    8.93 5771.77    2.09 6722.16    6.28
  7873.3    1.92 9463.34    9.0613283.11   11.1914076.97    9.9514312.22    2.16
14581.68    1.95 14919.7    9.8315639.23    8.5516202.13   35.3720703.13   38.18
#Mann= 5 ,-1 , 0
       0     .13       0 3512.05     .99       0 3777.76     .13       0
 4906.64     .03       0 5333.64     .13       0
Bank Sta=4906.64,5333.64
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,93063.22,6014.7,6812.27,2631.91
BEGIN DESCRIPTION:
sj17p325
Bank Station offset =     17714
---- FLOW CHANGE LOCATION
END DESCRIPTION:
XS GIS Cut Line= 6
     3220627.044     13869691.95     3215255.342    13869639.472
      3209536.23    13869464.959     3207127.102    13869484.855
     3204973.482    13869179.698     3201713.411    13868378.892
#Sta/Elev= 30
       0   38.22 2569.89   37.25 2727.97   31.59 2828.11      34 3163.63   26.68
 3192.98   24.39 3267.98    2.84 3350.39     2.6 3350.39     2.5 3486.39   -22.4
 3536.39   -22.4 3742.39     7.2  4602.1    1.83 6076.75    5.03 6508.61    1.47
 6639.83    4.89 8034.43    8.63 8189.87    5.45 8371.14    9.3711374.07   10.72
12094.46    5.2512571.14    5.3212601.15    9.4612789.12    1.5513139.73    1.53
13519.16    9.29 14115.1    5.4314637.82   32.8814740.48   35.0619036.33   38.26
#Mann= 3 , 0 , 0
       0     .13       0 3350.39     .03       0 3742.39     .13       0
Bank Sta=3350.39,3742.39
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,86250.95,2182.16,2276.04,2286.66
BEGIN DESCRIPTION:
sj16p025
Bank Station offset =     19269
END DESCRIPTION:
XS GIS Cut Line= 6
     3214704.311    13866842.333     3213726.502    13867177.583
     3211213.177    13868219.406     3205560.914    13867883.821
      3205401.15    13867792.206     3203724.905    13867568.706
#Sta/Elev= 30
       0   33.83 1103.94   35.94 1468.95    4.96  1479.3     .21  1910.3     .51
  1931.3    4.01  2131.3    5.41  2231.3    -.69  2747.3    2.21  3231.3  -13.79
  3404.3   -3.79  3644.3  -23.79  3709.3  -36.79  3826.3    5.71 4756.07    2.17
  6208.8    6.67 6238.85    2.25 6364.18     1.7 6875.88    2.96 7005.06    8.12
 7038.19    3.12 7178.04    1.54 7771.26    5.91 8720.75    1.07  8954.4   13.51
  9063.3   12.38 9185.63    27.6 9289.36   32.7510446.94   30.6411292.38   34.72
#Mann= 3 ,-1 , 0
       0     .13       0  2131.3     .03       0  3826.3     .13       0
Bank Sta=1479.3,3826.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,83974.91,1552.19,4067.32,4237.72
BEGIN DESCRIPTION:
sj15p6
Bank Station offset =     16749
---- FLOW CHANGE LOCATION
END DESCRIPTION:
XS GIS Cut Line= 6
     3214899.873    13866562.959      3213307.44    13866367.397
     3211672.351    13865672.947      3209665.24    13866502.422
     3205904.024    13866702.646      3203780.78    13867037.895
#Sta/Elev= 30
       0   34.31  1103.5   33.87 1443.54   29.92 1932.51   15.55 2140.29    14.2
 2207.87    8.25 2412.93    9.53  2539.5   14.43 2755.47   14.38 2987.72    5.61
 3506.55    6.96 3550.93    3.01 3620.93   -4.99 3730.93   -8.49 3850.93   -5.99
 4070.93  -15.29 4250.93   -7.99 4550.93   -4.49 5150.93   -8.79 5250.93    -.29
 8500.93     .21 8734.21    4.22 8810.92   16.33  9170.2   15.23 9484.47    32.1
10177.33   29.7810350.76   22.1510436.19   28.8110670.78   33.06 11491.7   32.57
#Mann= 5 ,-1 , 0
       0     .13       0 3550.93     .03       0 8500.93     .13       0
10177.33     .99       010436.19     .13       0
Bank Sta=3550.93,8500.93
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,79907.59,2003.7,4457.58,4880.86
BEGIN DESCRIPTION:
sj14p9, Xsec 4/4 of Union Pacific Railroad
Bank Station offset =     18753
END DESCRIPTION:
XS GIS Cut Line= 6
 3214045.8917436 13865992.143411     3213154.502    13865541.205
     3211957.208    13864935.515      3211210.66    13864428.426
     3205886.224    13863076.188     3203364.864    13862921.245
#Sta/Elev= 30
 -998.96   31.32   35.47    15.3  130.33   17.27  339.45    9.24  424.65   12.69
  718.02   13.13 1087.37    7.83 1357.52    7.97 1583.64    2.28 1729.69    5.54
 1855.17    3.26 2166.74    7.57 2261.25    5.95 2329.89    1.41 5163.89    1.21
 5471.89  -23.19 5571.89  -23.19 5621.89  -16.19 5671.89   -2.69 5746.89   -1.69
 7596.89    1.21 7616.02    1.54  7693.4   17.56 7760.45   23.17 7933.88   18.17
 8014.93   18.51    8118   23.03 8467.15   26.35 8586.03   29.6510263.84   31.09
#Mann= 5 ,-1 , 0
 -998.96     .11       0 2329.89     .04       0 7596.89     .11       0
 7760.45     .99       0    8118     .11       0
Bank Sta=2329.89,7596.89
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,75450.01,114.01,123.22,125.36
BEGIN DESCRIPTION:
sj14p023, Xsec 3/4 of Union Pacific Railroad
Bank Station offset =     16130
END DESCRIPTION:
XS GIS Cut Line= 6
 3214130.224227613865925.1481736     3213077.256     13865380.51
      3212403.38    13864972.637     3212098.066    13864639.713
     3211675.492    13863935.423     3207136.507    13857293.999
#Sta/Elev= 30
 -606.49   30.91  109.91    19.6   497.4   19.84  798.16    7.89  871.61    12.4
 1109.24    11.9 1978.55    2.15 3693.72    3.11 3837.12    5.97 4316.81    2.17
 4343.55    2.39 4369.81    9.72 4399.81    2.82 4565.81   -2.48 5068.81   -4.78
 7177.81   -2.28 8131.81    3.32 8183.81    2.52 8331.81  -23.08 8489.81  -21.08
 8661.81   -8.18 8685.81    2.52 8701.81   15.32 8741.81   22.42  8748.7    6.18
 8925.33   27.98 9024.93   33.95 9150.75   30.02 9822.67   26.0310684.14    28.3
#Mann= 3 , 0 , 0
 -606.49     .11       0 4369.81     .04       0 8741.81     .11       0
#XS Ineff= 2 , 0
       0    4369   14.32    8742       0   14.32
Permanent Ineff=
       F       F
Bank Sta=4369.81,8741.81
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,75388   ,,,
BEGIN DESCRIPTION:
Union Pacific RailRoad
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
54,15,3,0, 57, 57, , , .95, 0, 0,0,,
    -628    3870    3970    4070    4170    4270    4370    4370    4470    4570
    4670    4770    4870    4870    4970    5070    5170    5270    5370    5370
    5470    5570    5670    5770    5870    5970    6070    6170    6270    6370
    6470    6570    6670    6770    6870    6970    7070    7170    7270    7370
    7470    7570    7670    7770    7870    7970    8070    8170    8270    8370
    8470    8570    8742    8743    8770    8812   11000
   34.22   14.32   14.32   14.32   14.32   14.52   14.92   14.52   14.72   15.02
   15.32   15.62   16.02   16.72   16.42   16.92   17.42   17.72   18.12   18.82
   18.52   18.82   19.22   19.62   19.92   20.32   20.62   21.02   21.42   21.82
   22.22   22.62   22.62   23.42   23.72   24.12   24.32   24.72   25.02   25.32
   25.72   26.02   26.02   26.12   26.32   26.32   26.52   26.62   26.92   26.92
   26.92   26.92   26.92   26.92   27.22   34.22   34.22
     -30     -30     -30     -30     -30     -30     -30   10.67   10.67   10.67
   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67
   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67
   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67
   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67
   10.67   10.67   10.67     -30     -30     -30     -30
 -628.57 3869.43 3969.43 4069.43 4169.43 4269.43 4369.43 4369.43 4469.43 4569.43
 4669.43 4769.43 4869.43 4869.43 4969.43 5069.43 5169.43 5269.43 5369.43 5369.43
 5469.43 5569.43 5669.43 5769.43 5869.43 5969.43 6069.43 6169.43 6269.43 6369.43
 6469.43 6569.43 6669.43 6769.43 6869.43 6969.43 7069.43 7169.43 7269.43 7369.43
 7469.43 7569.43 7669.43 7769.43 7869.43 7969.43 8069.43 8169.43 8269.43 8369.43
 8469.43 8569.43 8741.43 8742.43 8769.43 8811.4311036.43
   34.22   14.32   14.32   14.32   14.32   14.52   14.92   14.52   14.72   15.02
   15.32   15.62   16.02   16.72   16.42   16.92   17.42   17.72   18.12   18.82
   18.52   18.82   19.22   19.62   19.92   20.32   20.62   21.02   21.42   21.82
   22.22   22.62   22.62   23.42   23.72   24.12   24.32   24.72   25.02   25.32
   25.72   26.02   26.02   26.12   26.32   26.32   26.52   26.62   26.92   26.92
   26.92   26.92   26.92   26.92   27.22   34.22   34.22
     -30     -30     -30     -30     -30     -30     -30   10.67   10.67   10.67
   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67
   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67
   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67
   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67   10.67
   10.67   10.67   10.67     -30     -30     -30     -30
Pier Skew, UpSta & Num, DnSta & Num=  ,5312, 2 ,5194.43, 2 , 0 , 0 , 0 ,,
      20      20
      -8      20
      20      20
      -8      20
Pier Skew, UpSta & Num, DnSta & Num=  ,6008, 2 ,5889, 2 , 0 , 0 , 0 ,,
      20      20
      -8      20
      20      20
      -8      20
Pier Skew, UpSta & Num, DnSta & Num=  ,6704, 2 ,6585, 2 , 0 , 0 , 0 ,,
      20      20
      -8      20
      20      20
      -8      20
Pier Skew, UpSta & Num, DnSta & Num=  ,8360, 2 ,8360, 2 , 0 , 0 , 0 ,,
      20      20
      -8      20
      20      20
      -8      20
Pier Skew, UpSta & Num, DnSta & Num=  ,8518, 2 ,8518, 2 , 0 , 0 , 0 ,,
      20      20
      -8      20
      20      20
      -8      20
BR Coef=-1 , 1 , 1 ,1.25, 0 ,,,.8,-1,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,

Type RM Length L Ch R = 1 ,75326.78,4260.4,2358.48,1349.6
BEGIN DESCRIPTION:
sj14p00, Xsec 2/4 of Union Pacific Railroad
Bank Station offset =     16167
---- FLOW CHANGE LOCATION
END DESCRIPTION:
XS GIS Cut Line= 6
     3213733.398     13865628.78     3212421.618    13864805.051
     3210189.587    13861571.637     3208298.479    13858769.292
     3208413.325    13858606.283     3207721.715    13857524.535
#Sta/Elev= 30
   36.43   24.49  632.73   23.48  926.61    8.75 1652.12    2.26 1949.08   22.34
 2312.91   14.85  2545.7   18.49 2709.61    2.46 3026.69    2.52 3117.15   13.97
  3297.3   15.71 4068.76   10.23 4331.08   13.52 4369.81    9.72 4399.81    2.82
 4565.81   -2.48 7177.81   -2.28 8131.81    3.32 8183.81    2.52 8331.81  -23.08
 8489.81  -21.08 8661.81   -8.18 8685.81    2.52 8701.81   15.32 8741.81   22.42
 8765.25    1.14 8785.76    1.14 8875.91   24.75 8930.89   30.1710378.63   28.37
#Mann= 3 ,-1 , 0
   36.43     .11       0 4565.81     .04       0 8741.81     .11       0
#XS Ineff= 2 , 0
   36.43 4368.43    12.5 8742.43   36.43    12.5
Permanent Ineff=
       F       F
Bank Sta=4369.81,8741.81
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,72968.31,2762.73,5043.85,4250.53
BEGIN DESCRIPTION:
sj13p53, Xsec 1/4 of Union Pacific Railroad
Bank Station offset =     19320
END DESCRIPTION:
XS GIS Cut Line= 6
     3216623.971    13865681.981      3215825.96     13864883.97
     3210663.151    13859140.489     3210792.969    13858676.087
     3209512.807    13858287.079     3207987.719    13857630.937
#Sta/Elev= 30
       0   33.92  617.44   34.98  659.87   31.79  746.65   33.99 1126.56   32.38
 1390.85    19.7 1729.59   10.75 1862.13     .32 8722.13    -.68 8762.13  -11.58
 8812.13  -18.88 8992.13  -23.08 9057.13  -21.58 9127.13  -11.58 9147.13    -.48
 9313.23    2.34 9333.72    5.03 9419.63    2.18 9768.13    3.17 9832.71    6.72
10161.39    3.0910267.11    6.6510358.53   20.5110434.68   18.8910473.74   14.91
10544.62   24.4210814.26   30.5911153.13   25.1411761.25   31.3412331.97   30.85
#Mann= 4 ,-1 , 0
       0     .11       0 1862.13     .04       0 9147.13     .11       0
10434.68     .99       0
Bank Sta=1862.13,9147.13
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,67924.46,3230.67,2662.71,697.02
BEGIN DESCRIPTION:
sj12p50
Bank Station offset =     18126
---- FLOW CHANGE LOCATION
END DESCRIPTION:
XS GIS Cut Line= 6
     3216920.685    13862364.187     3215670.334    13860912.272
     3215256.549    13858885.471     3210321.581    13857920.428
     3209104.934     13857896.94     3208431.058    13857719.605
#Sta/Elev= 30
       0   32.22  308.81    32.3  375.09   26.33  396.96   26.86  597.27    8.27
  624.13     .22 1874.13   -1.58 1974.13  -18.08 2174.13  -11.58 2374.13  -10.08
 2474.13   -9.58 2574.13  -12.58 3074.13  -12.58 3894.13     .22 6474.13     .72
 6491.08    3.88 6665.58   10.86 6839.78   11.38 7071.86    8.38 7719.26    8.79
 7843.35    5.68  7950.9    8.39 8198.81    2.44 9175.84    3.28 9406.08     9.3
 9573.26   22.17 9738.46   27.01 9886.22   25.6910293.84   30.0610949.63   30.55
#Mann= 3 , 0 , 0
       0     .11       0  624.13     .04       0 6474.13     .11       0
Bank Sta=624.13,6474.13
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,65261.75,2980.6,2274.55,383.76
BEGIN DESCRIPTION:
sj11p91
Bank Station offset =     19409
---- FLOW CHANGE LOCATION
END DESCRIPTION:
XS GIS Cut Line= 6
     3219389.704     13860227.32     3218831.858    13859533.781
     3218140.372    13859153.514     3213362.654     13857854.79
     3209485.179    13857760.415     3208273.717    13857470.718
#Sta/Elev= 30
       0   31.66  805.78   30.54  946.68   12.93  990.09   10.71   990.9    4.93
  1007.9    3.93  1008.9   -4.77  1070.9  -14.07  1260.9  -14.07  1290.9  -18.07
  1370.9  -19.07  1790.9  -16.07  1840.9  -10.07  1870.9     .43  1900.9    3.93
  1930.9     .43  4590.9    3.03 4909.78    6.51 5006.54    2.26 5964.84    1.73
 6951.62    8.07 7813.04    4.29 8221.98    7.22 9243.38    1.5410221.24    5.76
10561.94    2.1310637.43    8.5110679.89   22.9310766.02   30.0611796.39   29.24
#Mann= 3 , 0 , 0
       0     .11       0   990.9     .04       0  4590.9     .11       0
Bank Sta=990.9,4590.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,62987.20,190.01,62987.2,593.31
BEGIN DESCRIPTION:
sj11p303
Bank Station offset =     20246
---- FLOW CHANGE LOCATION
END DESCRIPTION:
XS GIS Cut Line= 6
      3218881.86    13856543.122     3215272.301    13857948.897
     3214652.737    13857899.332     3210514.051     13856226.51
     3208139.255    13855778.594     3207472.743    13855504.148
#Sta/Elev= 30
       0   33.86  212.04   14.99  525.03   24.71  693.59   11.42  702.23    3.33
  792.23  -17.27  986.23  -28.77 1183.23  -27.07 1267.23  -10.57 1352.23    -6.5
 1405.23    3.53 2846.23    5.03 3239.23   10.78 3245.53     3.5 3484.53    1.36
 5016.15    2.75 5232.63    7.49 5454.24    3.12    6616    3.14 6757.76    4.05
 6840.03   15.47 6914.15   19.01 6990.43    6.42 7066.72    3.57 9835.42     1.5
10452.62    7.5410687.98   23.8410935.59   31.92 11225.5    27.712107.44   29.89
#Mann= 3 , 0 , 0
       0     .11       0  702.23    .035       0 3239.23     .11       0
Bank Sta=702.23,3239.23
XS Rating Curve= 0
Exp/Cntr=.3,.1

Chan Stop Cuts=-1
