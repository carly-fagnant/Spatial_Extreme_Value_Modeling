HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 3 ,138395  ,,,
BEGIN DESCRIPTION:
ELDRIDGE PKYY
Structure ID: K100-00-00-S21
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,30,2.6,0, 60, 60, , , .95, 0, ,,,
 -1722.7  -622.7  -452.7  -402.7  -332.7  -292.7  -192.7  -152.7   -72.7     7.3
   137.3   307.3   987.3  1027.3  1057.3  1077.3  1117.3  1197.3  1227.3  1257.3
  1297.3  1397.3  1647.3  1757.3  2027.3  2057.3  2077.3  2527.3  4595.1 4829.79
  4829.9  4871.6 4871.69  5097.5  5310.8 5310.89  5400.7 5400.81  5530.6  6221.5
  6311.5  6551.5  6661.5  7091.5  7511.5  7561.5  7591.5  7621.5  7731.5  8061.5
  8501.5  8631.5  8751.5  8801.5  8911.5  9161.5  9341.5  9771.5  9851.5 10008.2
   135.5   134.2     132   133.5   131.5   133.5   132.7   130.2   133.1   133.2
     131     133     131   138.8   140.5   139.2   132.6   133.1   129.7   132.2
   132.6   130.2   131.1   128.8   128.9     127   128.3     130   132.3  134.41
  137.01  137.01  137.01  137.04  136.85  136.85   136.6     134   132.1   129.9
   131.7   132.2   128.9   131.8   129.4   131.4   130.2   132.5   132.7     131
   132.4   130.5   133.4   131.1   132.5   130.1   132.6   129.9   131.4   130.4
                                                                                
                                                                                
                                                                                
                  130.71  130.74  130.55
                                                                                
                                                                                
 -1722.7  -622.7  -452.7  -402.7  -332.7  -292.7  -192.7  -152.7   -72.7     7.3
   137.3   307.3   987.3  1027.3  1057.3  1077.3  1117.3  1197.3  1227.3  1257.3
  1297.3  1397.3  1647.3  1757.3  2027.3  2057.3  2077.3  2527.3  4595.1 4829.79
  4829.9  4871.6 4871.69  5097.5  5310.8 5310.89  5400.7 5400.81  5530.6  6221.5
  6311.5  6551.5  6661.5  7091.5  7511.5  7561.5  7591.5  7621.5  7731.5  8061.5
  8501.5  8631.5  8751.5  8801.5  8911.5  9161.5  9341.5  9771.5  9851.5 10008.2
   135.5   134.2     132   133.5   131.5   133.5   132.7   130.2   133.1   133.2
     131     133     131   138.8   140.5   139.2   132.6   133.1   129.7   132.2
   132.6   130.2   131.1   128.8   128.9     127   128.3     130   132.3  134.41
  137.01  137.01  137.01  137.04  136.85  136.85   136.6     134   132.1   129.9
   131.7   132.2   128.9   131.8   129.4   131.4   130.2   132.5   132.7     131
   132.4   130.5   133.4   131.1   132.5   130.1   132.6   129.9   131.4   130.4
                                                                                
                                                                                
                                                                                
                  130.71  130.74  130.55
                                                                                
                                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4944.5, 2 ,4944.5, 2 , 0 , 0 , 0 ,,
       3       3
  114.64  131.72
       3       3
  114.95  132.03
Pier Skew, UpSta & Num, DnSta & Num=  ,5017.3, 2 ,5017.3, 2 , 0 , 0 , 0 ,,
       3       3
  102.43  131.73
       3       3
  102.74  132.04
Pier Skew, UpSta & Num, DnSta & Num=  ,5090.6, 2 ,5090.6, 2 , 0 , 0 , 0 ,,
       3       3
  118.59  131.74
       3       3
   118.9  132.05
Pier Skew, UpSta & Num, DnSta & Num=  ,5164.1, 2 ,5164.1, 2 , 0 , 0 , 0 ,,
       3       3
  116.42  131.72
       3       3
  116.73  132.03
Pier Skew, UpSta & Num, DnSta & Num=  ,5237.2, 2 ,5237.2, 2 , 0 , 0 , 0 ,,
       3       3
  118.24  131.71
       3       3
  118.55  132.02
BR Coef= 1 , 1 , 1 ,.9, 0 ,,,.8,0,1.2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=140.48

Type RM Length L Ch R = 1 ,138363  ,136.3,99,94.9
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
       3040071.7     13920424.31      3041720.91     13915446.14
      3042957.42      13914133.3      3045296.94     13910081.19
#Sta/Elev= 30
 -1722.7  135.79   987.3  131.29  1057.3  140.79  1117.3  132.89  1227.3  129.99
  2277.3  128.29  2897.3  138.19  3007.3  129.69  3057.3  135.39  3097.3  131.69
  3197.3  135.59  3237.3  130.49  3377.3  136.39    3526  132.99    3556  125.99
    3676  124.99  3735.8  130.36    4406  120.99  4900.4  124.46  4976.7  105.59
  5018.9  103.72  5037.5  112.72  5097.5  121.04    5196  117.79    5296  120.79
  5331.5  126.39  5561.5  124.49  5741.5  131.59  5941.5  131.89 10008.2  130.69
#Mann= 5 ,-1 , 0
 -1722.7     .99       0  3735.8     .12       0  4900.4     .06       0
  5331.5     .12       0  5941.5     .99       0
#XS Ineff= 2 , 0
       0 4866.32  129.73 5340.28       0  129.73
Permanent Ineff=
       F       F
Bank Sta=4900.4,5331.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,138264. ,402.9,314,378
BEGIN DESCRIPTION:
K100-00-00-S21_ELDRIDGE PKWY -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 5
      3040164.22      13920202.5      3042198.56     13915593.92
      3042631.21     13914617.49      3043036.58     13914184.42
       3045376.1     13910132.32
#Sta/Elev= 30
 -1314.3  135.38   -14.3  130.31    65.7  133.25   625.7  129.43  1945.7  130.78
  2995.7  124.19  3853.4  125.07  3943.4   117.7  4033.4  125.01  4153.4  125.33
  4203.4   113.6  4323.4  111.72  4363.4     115  4403.4  124.32  4891.4  122.25
 4986.67  104.15 5014.58  103.54 5030.21  110.57  5121.4  122.07  5311.4  120.84
  5381.4  113.38  5754.6  128.69  6384.6  131.76  8104.6  130.48  8364.6  133.92
  8424.6   132.8  8484.6  124.35  8584.6  131.03  8744.6  132.22 10063.6  130.23
#Mann= 5 ,-1 , 0
 -1314.3     .99       0  1945.7     .12       0  4891.4     .06       0
  5121.4     .12       0  6384.6     .99       0
#XS Ineff= 2 , 0
        4720.663129.5598
Permanent Ineff=
       F       F
#Block Obstruct= 5 ,-1
 3825.06 4045.71  124.69 3836.09 3836.09  124.53    4145 4409.77  123.62
 5292.36 5667.45  120.66  8434.6  8584.6     131
Bank Sta=4891.4,5121.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,137950  ,1500.2,1984,2063.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X36D
END DESCRIPTION:
XS GIS Cut Line= 4
     3040174.461    13920214.494      3042593.25     13914978.99
      3043754.79     13914123.13      3046612.78      13910745.5
#Sta/Elev= 30
 -1337.5   135.8  -167.5     132  -117.5     134   162.5   130.5   262.5   133.3
   512.5   133.4   782.5   129.4   862.5     132  1362.5   131.5  1412.5   129.3
  1619.2  130.91  2102.5     131  2152.5   128.8  3352.5   123.3  4242.5   126.5
  4332.5   117.7  4372.5   118.2  4442.5   125.4  4937.1  121.52  4964.1  113.96
    4984  103.65  5000.9  102.98  5016.5  104.06  5025.7  111.25  5104.8  120.28
  5573.2   123.7  5623.2   120.3  5703.2   128.4    6326   130.3 10470.5   131.7
#Mann= 5 ,-1 , 0
 -1337.5     .99       0  1619.2     .12       0  4937.1     .06       0
  5104.8     .12       0    6326     .99       0
#XS Ineff= 2 , 0
         4258.68  129.02 5692.71           129.2
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
    4256    4442   125.4    5000  5000.1      50
Bank Sta=4937.1,5104.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,135966  ,2031,1740,1081.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X36C
END DESCRIPTION:
XS GIS Cut Line= 4
      3040272.32     13920063.15      3043373.01     13915945.21
      3044282.68     13916346.24      3049103.96     13911326.27
#Sta/Elev= 30
  -644.7   136.3   365.3   133.5   425.3   130.8   765.3   133.1   995.3   129.7
  1435.3   132.2  3385.3   129.3  4175.3   117.8  4265.3   120.6  4385.3   118.5
  4530.1   123.7  4700.1   122.7  4770.1   118.8  4876.6  122.98  4910.9  117.09
  4953.3  119.13  4975.9   107.3  4979.5  102.58  5020.5  101.82  5060.6  123.26
  5440.1   120.3  5644.2     123  6734.2   121.8  7824.2   128.1 11664.2   129.8
 11744.2   128.5 11794.2   122.5 11854.2   130.2 11964.2   133.3 12464.5   132.9
#Mann= 5 ,-1 , 0
  -644.7     .99       0  3385.3     .12       0  4953.3     .06       0
  5060.6     .12       0  7824.2     .99       0
#Block Obstruct= 2 ,-1
    5000  5000.1       1   11664   11855   129.8
Bank Sta=4953.3,5060.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,134226  ,147.6,222,282.9
BEGIN DESCRIPTION:
Cross Section XS36.7
END DESCRIPTION:
XS GIS Cut Line= 4
      3041204.89      13920521.7      3044930.07      13917212.8
      3044911.22     13917043.13      3049503.39     13912717.03
#Sta/Elev= 30
   -50.5   134.6   499.5   132.5   739.5   135.6   869.5   131.3  1739.5   131.9
  2509.5   129.9  2529.5   127.6  2549.5   130.5  3129.5   127.5  3669.5   128.9
  4629.5   126.7  4739.5   119.6  4909.5   120.2  4952.1   117.2  4963.7  109.59
    4987  101.94  5012.6  102.31  5042.1   114.2  5092.1   116.8  5252.8   118.6
  5312.8   122.2  5502.8   119.6  5832.8   122.8  6402.8   121.6  6462.8   119.3
  9512.8   131.8 10072.8   128.9 10122.8   121.3 10182.8   129.3 11411.7   130.1
#Mann= 5 ,-1 , 0
   -50.5     .99       0  3669.5     .12       0  4909.5     .06       0
  5092.1     .12       0  9512.8     .99       0
#Block Obstruct= 1 ,-1
10072.84 10182.2   128.9
Bank Sta=4909.5,5092.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,134004. ,107.8,66,82.2
BEGIN DESCRIPTION:
K100-00-00-S20_GRANT RD -US- XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3041370.54      13920476.5      3044921.17      13917336.7
      3045977.56     13916368.35      3049606.44     13912856.85
#Sta/Elev= 30
   -35.4   135.8   234.6  132.75   444.6  135.27   554.6  132.25   594.6  135.91
   734.6  131.02   994.6  133.32  2524.6  129.77  3544.6  129.41  4204.6  124.76
  4364.6  126.91  4514.6  125.26  4634.6  119.91  4884.4  120.01 4957.72  114.65
    4987  101.95 5015.09  103.49 5039.12  112.96 5074.67  118.96  5084.4  124.48
  5304.4  124.08  5414.4  117.85  5574.4  118.24  5684.4  122.34  6337.4  118.82
  9167.4  131.34  9667.4  129.02  9717.4  121.36  9777.4  129.57 11187.1  129.42
#Mann= 4 ,-1 , 0
   -35.4     .99       0  2524.6      .1       0  4884.4     .06       0
  5084.4     .12       0
#Block Obstruct= 1 ,-1
  9667.4  9777.4     129
Bank Sta=4884.4,5084.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,133938  ,110.7,94,106
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3041428.75     13920552.44      3044979.38     13917412.63
      3046035.77     13916444.27      3049664.65     13912932.77
#Sta/Elev= 30
   -61.9  136.01   348.1  133.31   438.1  137.01   498.1  132.71   638.1  135.51
   718.1  131.21   978.1  134.31  1058.1  131.81  1688.1  133.01  2248.1  131.91
  2378.1  128.51  2788.1  130.51  3718.1  127.21    4461  124.34  4717.9  118.81
    4909  124.48    4987  101.95    5009  101.95    5089  124.48  5277.9  122.01
 5592.21  118.55  5644.4  118.03  5837.9  121.41  6320.9  117.71  6390.9  120.81
  6830.9  120.01  9370.9  131.91 10230.9  128.31 10510.9  132.11 11160.6  129.71
#Mann= 6 ,-1 , 0
   -61.9     .99       0  3718.1     .12       0    4909    .035       0
  5277.9     .12       0 5592.21     .06       0  5644.4     .12       0
#XS Ineff= 2 , 0
       0  4894.5  123.75  5093.8       0   117.7
Permanent Ineff=
       F       F
Bank Sta=4909,5089
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 4 ,133891  ,,,
BEGIN DESCRIPTION:
GRANT ROAD
Structure ID: K100-00-00-S20
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,74,2.6,0, 60, 60, , , .95, 0, ,,,
   -61.9    78.1   348.1   438.1   498.1   538.1   568.1   638.1   658.1   718.1
   938.1   958.1   978.1  1058.1  1588.1  1688.1  1838.1  2198.1  2248.1  2268.1
  2358.1  2378.1  2428.1  2788.1  3178.1  3468.1  3768.1  3788.1  4498.1  4904.5
    4909    4969  5089.1  5109.5  5233.4 5592.21  5592.3 5592.39  5592.5  5644.4
 5644.51 5644.59  6130.9  6150.9  6290.9  6320.9  6390.9  6780.9  6830.9  7190.9
  7730.9  8220.9  8320.9  8430.9  8700.9  8760.9  8960.9  8990.9  9070.9  9110.9
  136.01  133.51  133.31  137.01  132.71  132.41  135.71  135.51  132.81  131.21
  133.61  132.41  134.31  131.81  131.01  133.01  130.91  130.31  131.91  130.51
  130.11  128.51  130.21  130.51  127.81  129.01  126.51  127.51  123.76  126.82
  127.56  127.56  127.56  126.56  124.31  123.61  123.74  123.86  126.46  126.39
  123.79  123.54  120.91  119.61  119.81  117.71  120.81  121.61  120.01  123.91
  123.81  126.91  125.81  127.61  128.51  130.21  130.81  129.51  129.61  131.11
                                                                                
                                                                                
                                                                                
  124.48  124.84  124.48                          121.43  121.55  121.55  121.48
  121.48
                                                                                
   -61.9    78.1   348.1   438.1   498.1   538.1   568.1   638.1   658.1   718.1
   938.1   958.1   978.1  1058.1  1588.1  1688.1  1838.1  2198.1  2248.1  2268.1
  2358.1  2378.1  2428.1  2788.1  3178.1  3468.1  3768.1  3788.1  4498.1  4904.5
    4909    4969  5089.1  5109.5  5233.4 5592.21  5592.3 5592.39  5592.5  5644.4
 5644.51 5644.59  6130.9  6150.9  6290.9  6320.9  6390.9  6780.9  6830.9  7190.9
  7730.9  8220.9  8320.9  8430.9  8700.9  8760.9  8960.9  8990.9  9070.9  9110.9
  135.99  133.49  133.29  136.99  132.69  132.39  135.69  135.49  132.79  131.19
  133.59  132.39  134.29  131.79  130.99  132.99  130.89  130.29  131.89  130.49
  130.09  128.49  130.19  130.49  127.79  128.99  126.49  127.49  123.74   126.8
  127.56  127.56  127.56  126.54  124.29  123.59  123.72  123.84  126.44  126.37
  123.77  123.52  120.89  119.59  119.79  117.69  120.79  121.59  119.99  123.89
  123.79  126.89  125.79  127.59  128.49  130.19  130.79  129.49  129.59  131.09
                                                                                
                                                                                
                                                                                
  124.46  124.82  124.46                          121.43  121.55  121.55  121.48
  121.48
                                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4969, 2 ,4969, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  100.63  124.84
     1.5     1.5
  100.63  124.84
Pier Skew, UpSta & Num, DnSta & Num=  ,5029, 2 ,5029, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  100.63  124.84
     1.5     1.5
  100.63  124.84
Pier Skew, UpSta & Num, DnSta & Num=  ,5610.1, 2 ,5610.1, 2 , 0 , 0 , 0 ,,
       1       1
  116.71  122.53
       1       1
  116.71  122.53
Pier Skew, UpSta & Num, DnSta & Num=  ,5627.2, 2 ,5627.2, 2 , 0 , 0 , 0 ,,
       1       1
  116.87   122.5
       1       1
  116.87   122.5
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Mult= 3 ,-1061.9,5422.63,-1061.9,5422.63
BC Mult= 3 ,5252.97,12160.6,5252.97,12160.6
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=137

Type RM Length L Ch R = 1 ,133844  ,151,124,41.7
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
       3041471.5     13920594.91      3045022.27     13917454.98
      3046078.98     13916486.33      3049708.06     13912974.63
#Sta/Elev= 30
   -61.9  135.99   348.1  133.29   438.1  136.99   498.1  132.69   638.1  135.49
   718.1  131.19   978.1  134.29  1058.1  131.79  1688.1  132.99  2378.1  128.49
  3718.1  127.19  4488.1  124.09  4928.6  115.97  4960.4  113.47  4963.7   109.6
    4987  101.95  5012.6  102.32  5034.5  112.35  5066.9  119.91  5277.9  121.99
 5592.21  118.53  5644.4  118.01  5837.9  121.39  6320.9  117.69  6390.9  120.79
  6830.9  119.99  9370.9  131.89 10230.9  128.29 10510.9  132.09 11160.6  129.69
#Mann= 7 ,-1 , 0
   -61.9     .99       0  3718.1     .12       0  4928.6     .06       0
  5066.9     .06       0  5277.9     .12       0 5592.21     .06       0
  5644.4     .12       0
#XS Ineff= 2 , 0
       0 4897.83  123.75 5090.47       0   117.7
Permanent Ineff=
       F       F
Bank Sta=4928.6,5066.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,133720. ,294.6,461,59.5
BEGIN DESCRIPTION:
K100-00-00-S20_GRANT RD -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3041637.26      13920691.5      3045301.05     13917450.69
      3045438.07     13917137.52      3049731.99     13913054.78
#Sta/Elev= 30
   -61.9   133.4  2988.1  129.42  3158.1  126.78  4118.1  127.64  4208.1  123.08
  4869.6  129.76  4909.6  117.91  4959.6  116.55    4987   101.8 5011.46  102.15
  5039.6  115.35  5089.6   123.6  5541.4  122.58  5671.4  113.79  5761.4  120.94
  6171.4  122.12  6261.4   118.9  6561.4  122.03  6891.4  120.79  7121.4  124.83
  8381.4  127.54  8431.4  125.07  8781.4  130.13  9271.4  129.23  9321.4  131.69
  9381.4  130.65  9441.4  120.64  9501.4  129.21  9541.4  130.17 11096.5  129.48
#Mann= 4 ,-1 , 0
   -61.9     .99       0  2988.1      .1       0  4869.6     .06       0
  5089.6     .12       0
Bank Sta=4869.6,5089.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,133259  ,1052.9,1606,971.3
BEGIN DESCRIPTION:
Cross Section XS36.2
END DESCRIPTION:
XS GIS Cut Line= 6
      3041905.69       13920790.      3045778.76     13917254.52
      3045725.36     13917149.21      3045675.03     13917048.55
      3045649.71     13917006.16       3049782.3     13913064.62
#Sta/Elev= 30
  -412.1   134.2   607.9   129.5   767.9   132.8  1037.9   128.8  3127.9     129
  3587.9   124.3  3787.9   128.2  4437.9   129.9  4507.9   125.8  4557.9   116.7
  4637.9   112.6  4687.9   117.1  4928.6  115.24  4960.4  112.74    4987  101.22
  5012.6  101.59  5040.1   119.8  5050.1   122.2    5202     123    5392   114.5
    5542   121.7    5982   117.3    6832   124.9    8062     126    8432   130.2
    9022   131.3    9102   122.2    9152   129.4    9202   130.1 10822.9   130.3
#Mann= 4 ,-1 , 0
  -412.1     .99       0  3787.9      .1       0  4507.9     .06       0
  5050.1     .12       0
#Block Obstruct= 1 ,-1
 9022.57 9204.86  129.77
Bank Sta=4507.9,5050.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,131653  ,476.6,1541,328.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X36B
END DESCRIPTION:
XS GIS Cut Line= 4
      3042756.79     13920894.57      3046444.35     13917950.38
      3046982.33     13917021.16      3049789.57     13913979.16
#Sta/Elev= 30
   -10.5   133.9  1169.5   128.7  1449.5   131.8  1989.5   127.9  3029.5   129.1
  3549.5   125.5  3639.5   128.8  4099.5   125.3  4886.2   127.7  4945.4  119.27
  4955.2  112.49  4972.3  111.19  4985.1  101.05  5001.4   99.15  5015.6  100.86
  5053.5  117.93  5378.2   114.3  5508.2   121.3    6252   118.2    7652   129.8
    7852   128.3    8772     130    8782   128.5    8802   118.7    8822   117.8
    8842   118.9    8872   129.4    8922   131.3    9572   128.4  9921.3   132.1
#Mann= 5 ,-1 , 0
   -10.5     .99       0  4886.2      .1       0  4945.4     .06       0
  5053.5     .12       0    7852     .99       0
#Block Obstruct= 2 ,-1
    5000  5000.1      50    8782    8869   128.5
Bank Sta=4945.4,5053.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,130112  ,435.9,1463,1082.3
BEGIN DESCRIPTION:
Cross Section XS36.1
END DESCRIPTION:
XS GIS Cut Line= 5
       3043999.7      13920194.1      3047425.27     13917691.78
      3047482.92     13917524.61      3047619.58     13916807.44
       3050122.5     13914106.26
#Sta/Elev= 30
   664.4   131.1  2364.4   128.7  4524.4   121.1  4604.4   106.6  4634.4   105.4
  4754.4   106.5  4834.4   118.3  4946.6   117.7  4965.3  113.84  4984.6   99.53
  5023.8  102.26  5050.1  108.77  5056.6   115.6  5076.6     119  5173.4   121.6
  5253.4   116.9  5583.4   118.7  5713.4   115.5  6383.5   128.5  6913.5   125.1
  7153.5   129.2  7523.5   130.5  7663.5   126.9  7893.5   130.5  7993.5   128.1
  8203.5   133.3  8263.5   119.1  8303.5     130  8333.5   131.2    9496   129.3
#Mann= 7 ,-1 , 0
   664.4     .99       0  2364.4      .1       0  4524.4    .025       0
  4834.4     .14       0  4946.6     .06       0  5076.6     .14       0
  7893.5     .99       0
#Block Obstruct= 2 ,-1
    4524  4834.4   118.3    8203    8333   131.2
Bank Sta=4946.6,5076.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,128649  ,800.8,1266,1078.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-XS36Extra
END DESCRIPTION:
XS GIS Cut Line= 4
      3044573.74     13919999.45      3048076.03     13917756.38
      3048684.72     13917154.16      3050660.29     13914542.04
#Sta/Elev= 30
   319.5   130.7  1779.5   124.6  2259.5   127.4  2439.5   123.1  3263.6  121.03
  3309.5   120.1  3399.5   107.3  3489.5     105  4029.5     105  4224.1  119.43
  4538.5     121  4965.3   114.2  4980.2  104.79  4984.6   99.89  5018.9  102.54
  5084.8  121.62  5185.2  118.05  5268.5   106.8  5434.8   108.2    5491  117.91
  5544.8   123.3  5704.8   125.5  6044.8   123.2  6344.8   129.3  6394.8   127.1
  6454.8   115.4  6494.8   116.2  6554.8   127.3  6604.8   128.7  8609.8   128.7
#Mann= 10 ,-1 , 0
   319.5     .99       0  2259.5      .1       0  3263.6    .025       0
  4224.1     .14       0  4965.3     .14       0  4980.2    .055       0
  5018.9     .14       0  5084.8     .14       0  5185.2    .025       0
    5491     .12       0
#Block Obstruct= 3 ,-1
    3277 4200.79  120.36 5084.48    5534  121.62    6345    6742  129.31
Bank Sta=4965.3,5084.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,127383. ,239.6,196,158.9
BEGIN DESCRIPTION:
K100-00-00-S19_CYPRESSWOOD -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 5
      3044766.27      13920270.8      3048166.28     13918542.19
      3048575.87     13918447.57      3049154.09     13918148.88
      3050860.05     13915839.92
#Sta/Elev= 30
   991.1  130.85  1091.1  128.18  1771.1  129.94  2391.1  125.06  3401.1   124.2
  4241.1  123.81  4401.1  118.01  4511.1  116.98  4571.1  120.86  4761.1  122.02
  4905.3  116.33 4978.44  104.58 4986.65   99.35 5010.06   98.62  5025.3   109.3
  5095.3  115.74  5255.7  119.26  5615.7  115.65  6066.5   120.2  6116.5  106.61
  6146.5  109.42  6166.5  117.95  6196.5  120.95  6486.5  126.09  6666.5  127.42
  6776.5   124.5  7356.5  127.37  7536.5  125.06  8096.5  129.95  8747.3  129.81
#Mann= 6 ,-1 , 0
   991.1      .1       0  3401.1     .06       0  4401.1     .12       0
  4905.3     .06       0  5095.3     .14       0  6066.5      .1       0
#Block Obstruct= 1 ,-1
 6044.13 6319.94  119.77
Bank Sta=4905.3,5095.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,127187  ,109.2,108,111.6
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3044812.93     13920461.41       3048079.9     13918847.49
       3049234.1     13918280.17      3050906.71     13916030.46
#Sta/Elev= 30
   981.5  130.91  1121.5  128.81  1571.5  130.11  1801.5  127.31  2991.5  127.31
  3271.5  123.31  4191.5  124.11  4237.6  121.18  4511.5  118.11  4581.5  113.71
  4820.6  120.08  4931.8  113.82    4974  107.09  4987.5   98.62    5014   98.42
  5020.4  103.96  5035.4  107.06  5088.2  106.93  5126.3  116.75  5167.7  117.63
  5332.2  116.25  5605.4  114.61  5885.3  121.11  6141.5  118.51  6481.5  121.91
  6621.5  125.21  6901.5  123.31  7341.5  127.91  8401.5  127.81  8714.8  130.81
#Mann= 6 ,-1 , 0
   981.5     .99       0  4237.6     .12       0  4820.6     .06       0
  5167.7     .06       0  5332.2     .14       0  6481.5     .99       0
#XS Ineff= 2 , 0
       0 4817.71  124.73 5177.65       0  121.15
Permanent Ineff=
       F       F
Bank Sta=4820.6,5167.7
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,127133  ,,,
BEGIN DESCRIPTION:
CYPRESSWOOD CROSSING #3
Structure ID: K100-00-00-S19
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,88,2.6,0, 60, 60, , , .95, 0, ,,,
   981.5  1091.5  1121.5  1231.5  1351.5  1431.5  1571.5  1801.5  1951.5  2991.5
  3221.5  3271.5  3371.5  3471.5  3591.5  3641.5  4191.5  4231.5  4291.5  4421.5
  4481.5  4511.5  4581.5  4611.5 4793.49  4793.6 4830.31  4830.4  5088.8 5189.99
  5190.1  5201.9  5241.3 5241.41  5387.2  5417.8  5465.4  5555.4  5605.4  5885.3
  5991.5  6141.5  6301.5  6401.5  6541.5  6621.5  6901.5  6961.5  7091.5  7111.5
  7181.5  7341.5  7711.5  7941.5  8021.5  8081.5  8161.5  8401.5  8641.5  8714.8
   130.9   130.1   128.8   130.7   130.5   128.7   130.1   127.3     128   127.3
   125.3   123.3   124.7   123.3   124.7   123.7     125     125  125.29  125.92
  126.05  126.11  126.32  126.45  128.06  130.46  130.57  130.57  131.46  130.94
  130.94  130.85  130.57  128.17  126.87   124.9   124.7   123.3  122.97   121.1
   121.1   118.5   119.7   122.4     122   125.2   123.3   124.8   125.9     125
   126.8   127.9   126.9   127.9     127   129.2   129.5   127.8   130.9   130.8
   130.9   130.1   128.8   130.7   130.5   128.7   130.1   127.3     128   127.3
   125.3   123.3   124.7   123.3   124.7   123.7   124.1   121.3     120   119.7
   117.9   118.1   113.7   115.5  119.77  119.77  119.44  124.37  125.26  124.74
  117.19  116.97  116.81  116.81  116.05  116.38   117.1   116.2   114.6   121.1
   121.1   118.5   119.7   122.4     122   125.2   123.3   124.8   125.9     125
   126.8   127.9   126.9   127.9     127   129.2   129.5   127.8   130.9   130.8
   981.5  1091.5  1121.5  1231.5  1351.5  1431.5  1571.5  1801.5  1951.5  2991.5
  3221.5  3271.5  3371.5  3471.5  3591.5  3641.5  4191.5  4231.5  4291.5  4421.5
  4481.5  4511.5  4581.5  4611.5 4793.49  4793.6 4830.31  4830.4  5088.8 5189.99
  5190.1  5201.9  5241.3 5241.41  5387.2  5417.8  5465.4  5555.4  5605.4  5885.3
  5991.5  6141.5  6301.5  6401.5  6541.5  6621.5  6901.5  6961.5  7091.5  7111.5
  7181.5  7341.5  7711.5  7941.5  8021.5  8081.5  8161.5  8401.5  8641.5  8714.8
  131.07  130.27  128.97  130.87  130.67  128.87  130.27  127.47  128.17  127.47
  125.47  123.47  124.87  123.47  124.87  123.87     125     125  125.29  125.92
  126.05  126.11  126.32  126.45  128.06  130.46  130.57  130.57  131.46  130.94
  130.94  130.85  130.57  128.17  126.87   124.9   124.7   123.3  122.97  121.27
  121.27  118.67  119.87  122.57  122.17  125.37  123.47  124.97  126.07  125.17
  126.97  128.07  127.07  128.07  127.17  129.37  129.67  127.97  131.07  130.97
  131.07  130.27  128.97  130.87  130.67  128.87  130.27  127.47  128.17  127.47
  125.47  123.47  124.87  123.47  124.87  123.87  124.27  121.47  120.17  119.87
  118.07  118.27  113.87  115.67  119.94  119.94  119.61  124.54  125.43  124.91
  117.36  117.14  116.98  116.98  116.22  116.55  117.27  116.37  114.77  121.27
  121.27  118.67  119.87  122.57  122.17  125.37  123.47  124.97  126.07  125.17
  126.97  128.07  127.07  128.07  127.17  129.37  129.67  127.97  131.07  130.97
Pier Skew, UpSta & Num, DnSta & Num=  ,4912.1, 2 ,4912.1, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  113.91  125.69
     1.5     1.5
  114.08  125.86
Pier Skew, UpSta & Num, DnSta & Num=  ,4984, 2 ,4984, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   98.65  126.03
     1.5     1.5
   98.83   126.2
Pier Skew, UpSta & Num, DnSta & Num=  ,5056.5, 2 ,5056.5, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  106.87  126.22
     1.5     1.5
  107.04  126.39
Pier Skew, UpSta & Num, DnSta & Num=  ,5127.9, 2 ,5127.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  115.59  126.12
     1.5     1.5
  115.76  126.29
Abutment Skew #Up #Dn= , 2 , 2
  4830.2    4879
  124.37   116.2
  4830.2    4879
  124.54  116.37
Abutment Skew #Up #Dn= , 2 , 2
  5163.7 5190.19
   116.8  124.74
  5163.7 5190.19
  116.97  124.91
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=130.91

Type RM Length L Ch R = 1 ,127079  ,207,202,229.5
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3044864.51     13920555.35      3048131.46     13918941.44
      3049289.98       13918372.      3050965.48      13916118.4
#Sta/Elev= 30
   981.5  131.07  1121.5  128.97  1571.5  130.27  1801.5  127.47  2991.5  127.47
  3271.5  123.47  4191.5  124.27  4237.6  121.34  4511.5  118.27  4581.5  113.87
  4820.6  120.24  4931.8  113.98    4974  107.25  4987.5   98.78    5014   98.58
  5020.4  104.12  5035.4  107.22  5088.2  107.09  5126.3  116.91  5167.7  117.79
  5332.2  116.41  5605.4  114.77  5885.3  121.27  6141.5  118.67  6481.5  122.07
  6621.5  125.37  6901.5  123.47  7341.5  128.07  8401.5  127.97  8714.8  130.97
#Mann= 6 ,-1 , 0
   981.5     .99       0  4237.6     .12       0  4820.6     .06       0
  5167.7     .06       0  5332.2     .14       0  6481.5     .99       0
#XS Ineff= 2 , 0
       0 4809.03  124.46 5177.65       0  121.15
Permanent Ineff=
       F       F
Bank Sta=4820.6,5167.7
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,126877. ,895,1208,955.1
BEGIN DESCRIPTION:
K100-00-00-S19_CYPRESSWOOD -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3045006.22      13920708.1      3048273.18      13919094.2
       3049431.7     13918524.75      3051107.19     13916271.16
#Sta/Elev= 30
  1053.6  131.31  1323.6  130.58  1423.6  127.63  1473.6  130.15  2543.6  125.56
  3413.6  126.81  3533.6  123.02  3863.6  124.66  4203.6   121.6  4273.6  119.75
  4483.6  122.36  4737.5   115.9  4887.5   115.9 4976.77  104.71 4985.33   99.43
 5009.73   98.61  5017.5  105.75  5087.5  117.71  5417.5  118.21  5487.5  114.79
  5767.5  119.74  5787.5  116.61  5817.5  106.44  5857.5  117.22  5877.5  119.46
  6118.4  119.16  6588.4   118.5  7288.4  127.25  7708.4     125  8796.6  128.01
#Mann= 5 ,-1 , 0
  1053.6      .1       0  4203.6     .12       0  4887.5     .06       0
  5087.5     .14       0  6118.4      .1       0
#Block Obstruct= 1 ,-1
 5744.68 5894.41   119.2
Bank Sta=4887.5,5087.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,125669  ,849.1,759,168.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X36A
END DESCRIPTION:
XS GIS Cut Line= 4
      3045818.35     13921129.32      3048821.22     13919818.62
      3049378.76      13919984.9      3051178.53     13917774.32
#Sta/Elev= 30
  1447.3   129.7  2187.3     128  2247.3   125.4  3017.3   127.8  3197.3   123.5
  3347.3   127.7  3547.3   126.9  3777.3   122.6  4217.3   120.5  4347.3   112.2
  4723.8   118.2  4813.8   115.8  4897.8  119.13  4909.7  115.37  4929.4  114.58
  4945.1  108.53  4958.8  108.59  4984.2   98.79    5018   99.44  5043.1   106.8
  5054.8  122.99  5101.9  118.81  5305.6   116.3  6175.6   119.4  6245.6   122.6
  6535.6   119.4  6685.6     123  6885.6   122.2  7085.6   126.9  8156.2   126.8
#Mann= 5 ,-1 , 0
  1447.3     .99       0  3547.3     .14       0  4897.8     .06       0
  5054.8     .14       0  6245.6     .99       0
Bank Sta=4897.8,5054.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,124910. ,101.4,100,106
BEGIN DESCRIPTION:
K100-00-00-SJONES_JONES RD -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3045838.59      13921297.4      3048626.28     13920847.47
      3049526.16     13920074.74      3051306.36     13917815.25
#Sta/Elev= 30
  1740.4  130.06  2780.4  124.71  3820.4  126.52  4300.4  121.71  4490.4  118.54
  4734.2  119.45  4804.2  115.75  4894.2  114.89 4975.96  104.11 4996.92   96.51
 5011.76   98.62 5020.74  105.14 5031.24  104.56 5122.92  116.71  5234.2  118.98
  5564.2  116.36  6210.3  118.38  6380.3  119.42  6440.3  122.02  6480.3   119.6
  6600.3   121.6  6660.3  119.32  6790.3  122.38  7020.3  118.94  7150.3  123.04
  7330.3  124.39  7370.3  122.72  7450.3  126.69  7610.3  127.74  8626.8  126.23
#Mann= 5 ,-1 , 0
  1740.4      .1       0  4300.4     .14       0  4894.2     .06       0
 5122.92     .14       0  6210.3      .1       0
#XS Ineff= 2 , 0
         4486.21  123.15 5734.44          123.07
Permanent Ineff=
       F       F
Bank Sta=4894.2,5122.92
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,124810  ,115.9,116,120.7
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3045905.25     13921373.38      3048692.94     13920923.44
      3049592.82     13920150.71      3051373.03     13917891.22
#Sta/Elev= 30
  1749.7   129.9  2299.7   128.4  2539.7   125.1  3029.7   127.2  3579.7   124.4
  3879.7   126.2  4029.7   122.6  4239.7   123.4  4569.7   117.6  4603.5   121.3
  4862.2  117.31  4976.7  104.11  4998.6   96.21  5014.3   98.59  5023.8  105.97
  5131.9  115.88  5373.5   118.5  5663.5   116.3  6009.6   119.5  6349.6   118.7
  6459.6   121.5  6669.6   119.9  6859.6   122.5  7079.6   119.3  7149.6   122.9
  7289.6     125  7419.6     123  7479.6   126.8  7709.6   128.2  8636.1   126.1
#Mann= 6 ,-1 , 0
  1749.7     .99       0  4029.7     .14       0  4862.2     .06       0
  5131.9     .06       0  5373.5     .14       0  6669.6     .99       0
#XS Ineff= 2 , 0
       0 4826.39  124.38  5187.5       0  124.45
Permanent Ineff=
       F       F
Bank Sta=4862.2,5131.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,124751  ,,,
BEGIN DESCRIPTION:
JONES ROAD
Structure ID: K100-00-00-SJONES
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,98,2.6,0, 189, 189, , , .95, 0, ,,,
  1749.7  1779.7  1809.7  1849.7  2089.7  2119.7  2179.7  2299.7  2329.7  2369.7
  2419.7  2439.7  2449.7  2529.7  2539.7  2569.7  2619.7  2699.7  2799.7  2829.7
  2889.7  2909.7  2949.7  2999.7  3029.7  3169.7  3209.7  3379.7  3409.7  3499.7
  3519.7  3559.7  3579.7  3729.7  3739.7  3789.7  3859.7  3879.7  3909.7  3929.7
  3999.7  4029.7  4049.7  4059.7  4079.7  4109.7    4150  4197.9  4227.9  4239.7
  4247.9  4277.9  4289.7  4297.9  4299.7  4329.7  4349.7  4359.7  4379.7  4407.9
  4409.7  4417.9  4509.7  4512.9  4539.7  4549.7  4559.7  4569.7  4573.5  4583.5
  4593.5  4603.5  4613.5  4633.5  4652.1  4706.3    4758  4792.8  4810.8    4811
  4830.7  4830.8 4830.91  4832.4  4862.2  4880.2    4899    4902  4937.3  4941.5
  4966.9  4976.7  4984.9  4988.4  4997.5  4998.6  5014.3  5015.1  5023.8  5034.9
  5055.6  5064.4  5102.7  5115.2  5131.9 5170.09  5170.2 5170.31  5173.2 5173.39
  5173.5  5173.6  5190.5  5213.9  5216.3  5268.1  5318.1    5362  5373.5  5402.9
  5422.9  5432.9  5442.9  5467.7  5507.7  5517.7  5563.5  5583.5  5663.5  5677.7
  5687.7  5707.7  5743.5  5759.6  5779.6  5802.3  5969.6  6009.6  6029.6  6049.6
  6129.6  6159.6  6199.6    6220  6269.6  6319.6  6349.6  6399.6  6429.6  6459.6
  6489.6  6509.6  6539.6  6579.6  6619.6  6669.6  6729.6  6739.6  6759.6  6859.6
  6909.6  7039.6  7079.6  7089.6  7119.6  7149.6  7209.6  7289.6  7379.6  7399.6
  7419.6  7459.6  7479.6  7579.6  7609.6  7709.6  7739.6  7879.6  7899.6  8089.6
  8139.6  8159.6  8199.6  8289.6  8379.6  8509.6  8599.6  8629.6  8636.1
   129.9   129.9   129.4     130   129.1   129.3   128.9   128.4   127.8   127.7
   126.2   125.8   125.3   125.4   125.1     126   125.6   126.8   126.7   126.4
   126.9   126.6   127.1   126.9   127.2   126.8   127.1   126.9   126.3   126.7
   125.9   125.4   124.4   125.1   124.9     126   125.8   126.2   125.7   124.9
   124.6   122.6   123.4   124.3   123.1     123  123.12  123.28  123.37  123.41
  123.08  121.88  122.21   122.5   122.5  122.41  122.36  122.33  122.28   122.2
  122.27   122.6   122.7   122.7  123.07  123.21  123.35  123.49  123.54  123.68
  123.82  123.96   124.1  124.38  124.85  125.39  125.93  126.32  126.52  126.52
  126.69  133.87  133.87  133.91  134.64  135.09  135.17  135.19  135.34  135.35
  135.42  135.45  135.47  135.48  135.51  135.51  135.49  135.49  135.47  135.46
  135.43   135.4  135.28  135.24  134.91  134.14  134.14  126.34  126.28  126.27
  126.27  126.27  126.51  126.53   126.5  125.91  125.33  124.89  124.78   124.5
   123.9   124.2   123.7   123.6   122.4   122.4  121.66  121.33  120.03   119.8
   120.1   119.1  118.57  118.33  118.11  118.12   118.2   119.5   119.1   118.2
   118.4   119.8   120.1  119.87   119.3   119.7   118.7   120.3   120.3   121.5
   120.2   120.3   119.3     121   121.4   119.9   119.2   119.4   120.7   122.5
   120.8     121   119.3   119.5   121.9   122.9   123.4     125   124.2     123
     123   125.9   126.8   127.7   127.3   128.2   127.1     128   128.5     128
   125.6   125.5   127.2   126.5     127   124.9   126.4     126   126.1
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                  123.48  123.29  123.44  123.89  123.97  123.99  124.14  124.15
  124.22  124.25  124.27  124.28  124.31  124.31  124.29  124.29  124.27  124.26
  124.23   124.2  124.08  124.04  123.71  122.94  122.94
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                        
  1749.7  1779.7  1809.7  1849.7  2089.7  2119.7  2179.7  2299.7  2329.7  2369.7
  2419.7  2439.7  2449.7  2529.7  2539.7  2569.7  2619.7  2699.7  2799.7  2829.7
  2889.7  2909.7  2949.7  2999.7  3029.7  3169.7  3209.7  3379.7  3409.7  3499.7
  3519.7  3559.7  3579.7  3729.7  3739.7  3789.7  3859.7  3879.7  3909.7  3929.7
  3999.7  4029.7  4049.7  4059.7  4079.7  4109.7    4150  4197.9  4227.9  4239.7
  4247.9  4277.9  4289.7  4297.9  4299.7  4329.7  4349.7  4359.7  4379.7  4407.9
  4409.7  4417.9  4509.7  4512.9  4539.7  4549.7  4559.7  4569.7  4573.5  4583.5
  4593.5  4603.5  4613.5  4633.5  4652.1  4706.3    4758  4792.8  4810.8    4811
  4830.7  4830.8 4830.91  4832.4  4862.2  4880.2    4899    4902  4937.3  4941.5
  4966.9  4976.7  4984.9  4988.4  4997.5  4998.6  5014.3  5015.1  5023.8  5034.9
  5055.6  5064.4  5102.7  5115.2  5131.9 5170.09  5170.2 5170.31  5173.2 5173.39
  5173.5  5173.6  5190.5  5213.9  5216.3  5268.1  5318.1    5362  5373.5  5402.9
  5422.9  5432.9  5442.9  5467.7  5507.7  5517.7  5563.5  5583.5  5663.5  5677.7
  5687.7  5707.7  5743.5  5759.6  5779.6  5802.3  5969.6  6009.6  6029.6  6049.6
  6129.6  6159.6  6199.6    6220  6269.6  6319.6  6349.6  6399.6  6429.6  6459.6
  6489.6  6509.6  6539.6  6579.6  6619.6  6669.6  6729.6  6739.6  6759.6  6859.6
  6909.6  7039.6  7079.6  7089.6  7119.6  7149.6  7209.6  7289.6  7379.6  7399.6
  7419.6  7459.6  7479.6  7579.6  7609.6  7709.6  7739.6  7879.6  7899.6  8089.6
  8139.6  8159.6  8199.6  8289.6  8379.6  8509.6  8599.6  8629.6  8636.1
   129.9   129.9   129.4     130   129.1   129.3   128.9   128.4   127.8   127.7
   126.2   125.8   125.3   125.4   125.1     126   125.6   126.8   126.7   126.4
   126.9   126.6   127.1   126.9   127.2   126.8   127.1   126.9   126.3   126.7
   125.9   125.4   124.4   125.1   124.9     126   125.8   126.2   125.7   124.9
   124.6   122.6   123.4   124.3   123.1     123  123.12  123.28  123.37  123.41
  123.08  121.88  122.21   122.5   122.5  122.41  122.36  122.33  122.28   122.2
  122.27   122.6   122.7   122.7  123.07  123.21  123.35  123.49  123.54  123.68
  123.82  123.96   124.1  124.38  124.85  125.39  125.93  126.32  126.52  126.52
  126.69  133.87  133.87  133.91  134.64  135.09  135.17  135.19  135.34  135.35
  135.42  135.45  135.47  135.48  135.51  135.51  135.49  135.49  135.47  135.46
  135.43   135.4  135.28  135.24  134.91  134.14  134.14  126.34  126.28  126.27
  126.27  126.27  126.51  126.53   126.5  125.91  125.33  124.89  124.78   124.5
   123.9   124.2   123.7   123.6   122.4   122.4  121.66  121.33  120.03   119.8
   120.1   119.1  118.57  118.33  118.11  118.12   118.2   119.5   119.1   118.2
   118.4   119.8   120.1  119.87   119.3   119.7   118.7   120.3   120.3   121.5
   120.2   120.3   119.3     121   121.4   119.9   119.2   119.4   120.7   122.5
   120.8     121   119.3   119.5   121.9   122.9   123.4     125   124.2     123
     123   125.9   126.8   127.7   127.3   128.2   127.1     128   128.5     128
   125.6   125.5   127.2   126.5     127   124.9   126.4     126   126.1
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                  123.48  123.29  123.44  123.89  123.97  123.99  124.14  124.15
  124.22  124.25  124.27  124.28  124.31  124.31  124.29  124.29  124.27  124.26
  124.23   124.2  124.08  124.04  123.71  122.94  122.94
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4899, 2 ,4899, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  113.36  124.98
     1.5     1.5
  113.12  124.74
Pier Skew, UpSta & Num, DnSta & Num=  ,4966.9, 2 ,4966.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  103.76  125.22
     1.5     1.5
  103.52  124.98
Pier Skew, UpSta & Num, DnSta & Num=  ,5034.9, 2 ,5034.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  104.35  125.26
     1.5     1.5
  104.11  125.02
Pier Skew, UpSta & Num, DnSta & Num=  ,5102.7, 2 ,5102.7, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  113.05  125.08
     1.5     1.5
  112.81  124.84
Abutment Skew #Up #Dn= , 2 , 2
 4770.33 5170.33
   22.94  122.94
 4770.33 5170.33
   22.94  122.94
Abutment Skew #Up #Dn= , 2 , 2
 4830.85 5230.85
  123.48   23.48
 4830.85 5230.85
  123.48   23.48
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=130
