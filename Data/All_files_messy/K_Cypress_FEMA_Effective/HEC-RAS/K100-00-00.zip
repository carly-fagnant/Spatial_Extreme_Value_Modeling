HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,10629   ,89,95,80.9
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3128512.69      13943527.7      3129548.36     13940818.77
      3129653.36     13939807.51      3129637.69     13937324.57
#Sta/Elev= 30
1513.971      88 1556.42    83.8 2744.98      752780.297   68.992812.898    66.2
2863.836      733160.976    67.23228.894    74.93288.322    75.43424.157    67.8
3551.503    72.24089.072   62.634152.745   65.484165.904   61.894196.042   41.71
4263.621   41.374286.288   42.684351.999   62.714526.038   63.344551.932   56.95
4592.937   59.664593.361   65.524594.295   65.545127.959      625263.794    56.8
5594.893    69.25643.115   66.935736.501   71.466435.375    83.4 6947.22    80.2
#Mann= 6 , 1 , 0
1513.971      .1       02780.297     .14       04165.904    .055       0
4351.999     .14       05643.115      .1       05736.501     .99       0
#XS Ineff= 2 , 0
       0 4144.68   79.564634.112       0   79.56
Permanent Ineff=
       F       F
Bank Sta=4165.904,4351.999
XS Rating Curve= 0
Skew Angle= 31.9
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,10588.5 ,,,
BEGIN DESCRIPTION:
CYPRESSWOOD DRIVE
Structure ID: K100-00-00-S1
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,61,2.6,31.9, 199, 199, , , .95, 0, ,,,
1513.9711530.951 1556.421573.3991590.3791607.3581658.2961709.2351777.1521802.622
1819.601 1853.562048.823 2159.192422.3712430.8612677.0622711.021 2744.982761.959
2780.2972795.9182812.8982829.8772838.3672846.8572855.3462863.8362889.3052906.285
2923.2643152.4873160.9763186.4453194.9353211.9153228.8943288.3223330.7713336.374
 3339.263364.7293395.8023398.6883407.1783424.157 3438.25 3446.743517.5443526.034
3534.5243551.5033559.9933576.9723582.5753619.421  3636.43661.8693687.3383712.808
3729.7873731.3153831.6643840.1533882.6023891.0923916.5613959.009 3962.663963.161
3963.2543963.3484008.335  4020.94052.2274061.3114089.0724098.4114151.6424151.735
4151.8364151.8964152.7454165.9044177.7054181.1014188.3174196.042 4206.234215.993
4229.7474239.0854247.1514254.2824263.6214273.1294279.1574286.2884292.0614308.701
4320.9264330.435 4342.834351.9994373.8174411.766 4449.974487.6644526.0384542.423
4551.9324563.7324566.3644592.9374593.3614594.295 4619.064619.1624619.255 4619.34
 4623.334668.2414712.4724712.8124758.3164808.6614817.6514817.7444817.8384822.838
 4833.624839.3094847.7984856.2884868.9384870.2964873.2674881.7574898.7364907.226
4924.2064932.6954975.1444983.6345034.5725060.0415077.021 5085.515110.9795127.959
5144.9385161.9175178.8975184.4165195.8765201.3955204.3665212.8565226.8645235.354
5255.3055263.7945272.2845280.7745297.7535331.7125357.1815365.671 5382.65 5391.14
5425.0995459.0585493.0175509.9965543.9555560.9355569.4245594.8935643.1155645.832
5654.3215662.8115671.301 5705.265722.2395730.7295736.5015739.2185849.5855880.742
5900.5236409.9066435.3756545.7426613.6596690.0676834.392 6893.82 6947.22
      88    86.9    83.8    83.8    85.8    86.6    86.3    85.1    84.2    81.9
    81.7    83.5    81.5    80.4    77.5    77.1    74.8    74.3      75    71.8
   68.99    66.6    66.2    70.1    72.4    72.8    72.6      73    71.7    71.6
    70.4    67.5    67.2    69.4    70.4    73.2    74.9    75.4    74.8    75.4
    75.4    75.4    75.4    75.4    75.4    75.4    75.4    75.1   75.15   75.16
   75.16   75.18   75.18    75.2    75.2   75.13   75.09   75.04   74.99   74.94
    74.9    74.9   75.94   76.03   76.47   76.56   76.83   77.27    77.3   77.31
   79.51   79.51   79.51   79.51   79.55   79.56    79.6   79.61   79.67   79.67
   79.67   79.67   79.67   79.67   79.67   79.67   79.66   79.66   79.66   79.66
   79.66   79.66   79.66   79.65   79.65   79.65   79.65   79.65   79.65   79.65
   79.64   79.64   79.64   79.64   79.64   79.63   79.63   79.62   79.61   79.61
   79.61   79.61   79.61    79.6    79.6    79.6    79.6    79.6    79.6    79.6
   79.59   79.42   79.26   79.26    79.1   78.91   78.88   78.88   76.68   76.66
   76.39   76.25   76.03   75.82    75.5    75.5    75.5    75.5   75.49   75.49
   75.48   75.48   75.47   75.46   75.45   75.44   75.43   75.43   75.42   75.42
   75.41   75.41    75.4    75.4   75.27    75.2   75.21   75.24    75.3      75
   75.02   75.03   75.04   75.05   75.06    75.1   75.12   75.13   75.15   75.16
   75.19   75.22   75.26   75.27   75.31   75.32   75.33   75.36   75.41   75.41
   75.42   75.43   75.43   75.47   75.49   75.49    75.5    75.5   75.58   75.63
    76.4      83    83.4    82.1      82    82.5    80.1    80.3    80.2
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
   65.44   74.92   74.92   74.92   74.92   74.92   74.91   74.91   74.91   74.91
   74.91   74.91   74.91    74.9    74.9    74.9    74.9    74.9    74.9    74.9
   74.89   74.89   74.89   74.89   74.89   74.88   74.88   74.87   74.86   74.86
   74.86   74.86   74.86   74.85   74.85   74.85   74.85
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                        
1513.9711530.951 1556.421573.3991590.3791607.3581658.2961709.2351777.1521802.622
1819.601 1853.562048.823 2159.192422.3712430.8612677.0622711.021 2744.982761.959
2780.2972795.9182812.8982829.8772838.3672846.8572855.3462863.8362889.3052906.285
2923.2643152.4873160.9763186.4453194.9353211.9153228.8943288.3223330.7713336.374
 3339.263364.7293395.8023398.6883407.1783424.157 3438.25 3446.743517.5443526.034
3534.5243551.5033559.9933576.9723582.5753619.421  3636.43661.8693687.3383712.808
3729.7873731.3153831.6643840.1533882.6023891.0923916.5613959.009 3962.663963.161
3963.2543963.3484008.335  4020.94052.2274061.3114089.0724098.4114151.6424151.735
4151.8364151.8964152.7454165.9044177.7054181.1014188.3174196.042 4206.234215.993
4229.7474239.0854247.1514254.2824263.6214273.1294279.1574286.2884292.0614308.701
4320.9264330.435 4342.834351.9994373.8174411.766 4449.974487.6644526.0384542.423
4551.9324563.7324566.3644592.9374593.3614594.295 4619.064619.1624619.255 4619.34
 4623.334668.2414712.4724712.8124758.3164808.6614817.6514817.7444817.8384822.838
 4833.624839.3094847.7984856.2884868.9384870.2964873.2674881.7574898.7364907.226
4924.2064932.6954975.1444983.6345034.5725060.0415077.021 5085.515110.9795127.959
5144.9385161.9175178.8975184.4165195.8765201.3955204.3665212.8565226.8645235.354
5255.3055263.7945272.2845280.7745297.7535331.7125357.1815365.671 5382.65 5391.14
5425.0995459.0585493.0175509.9965543.9555560.9355569.4245594.8935643.1155645.832
5654.3215662.8115671.301 5705.265722.2395730.7295736.5015739.2185849.5855880.742
5900.5236409.9066435.3756545.7426613.6596690.0676834.392 6893.82 6947.22
      88    86.9    83.8    83.8    85.8    86.6    86.3    85.1    84.2    81.9
    81.7    83.5    81.5    80.4    77.5    77.1    74.8    74.3      75    71.8
   68.99    66.6    66.2    70.1    72.4    72.8    72.6      73    71.7    71.6
    70.4    67.5    67.2    69.4    70.4    73.2    74.9    75.4    74.8    75.4
    75.4    75.4    75.4    75.4    75.4    75.4    75.4    75.1   75.15   75.16
   75.16   75.18   75.18    75.2    75.2   75.13   75.09   75.04   74.99   74.94
    74.9    74.9   75.94   76.03   76.47   76.56   76.83   77.27    77.3   77.31
   79.51   79.51   79.51   79.51   79.55   79.56    79.6   79.61   79.67   79.67
   79.67   79.67   79.67   79.67   79.67   79.67   79.66   79.66   79.66   79.66
   79.66   79.66   79.66   79.65   79.65   79.65   79.65   79.65   79.65   79.65
   79.64   79.64   79.64   79.64   79.64   79.63   79.63   79.62   79.61   79.61
   79.61   79.61   79.61    79.6    79.6    79.6    79.6    79.6    79.6    79.6
   79.59   79.42   79.26   79.26    79.1   78.91   78.88   78.88   76.68   76.66
   76.39   76.25   76.03   75.82    75.5    75.5    75.5    75.5   75.49   75.49
   75.48   75.48   75.47   75.46   75.45   75.44   75.43   75.43   75.42   75.42
   75.41   75.41    75.4    75.4   75.27    75.2   75.21   75.24    75.3      75
   75.02   75.03   75.04   75.05   75.06    75.1   75.12   75.13   75.15   75.16
   75.19   75.22   75.26   75.27   75.31   75.32   75.33   75.36   75.41   75.41
   75.42   75.43   75.43   75.47   75.49   75.49    75.5    75.5   75.58   75.63
    76.4      83    83.4    82.1      82    82.5    80.1    80.3    80.2
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
   65.44   74.92   74.92   74.92   74.92   74.92   74.91   74.91   74.91   74.91
   74.91   74.91   74.91    74.9    74.9    74.9    74.9    74.9    74.9    74.9
   74.89   74.89   74.89   74.89   74.89   74.88   74.88   74.87   74.86   74.86
   74.86   74.86   74.86   74.85   74.85   74.85   74.85
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4177.705, 2 ,4177.705, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   49.87   75.92
     1.5     1.5
   50.17   76.22
Pier Skew, UpSta & Num, DnSta & Num=  ,4215.993, 2 ,4215.993, 2 , 0 , 0 , 0 ,,
     1.5     1.5
    43.7   75.91
     1.5     1.5
      44   76.21
Pier Skew, UpSta & Num, DnSta & Num=  ,4254.282, 2 ,4254.282, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   42.89    75.9
     1.5     1.5
   43.19    76.2
Pier Skew, UpSta & Num, DnSta & Num=  ,4292.061, 2 ,4292.061, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   43.91    75.9
     1.5     1.5
   44.21    76.2
Pier Skew, UpSta & Num, DnSta & Num=  ,4330.435, 2 ,4330.435, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   55.04   75.89
     1.5     1.5
   55.34   76.19
Pier Skew, UpSta & Num, DnSta & Num=  ,4373.817, 2 ,4373.817, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   62.42   75.89
     1.5     1.5
   62.72   76.19
Pier Skew, UpSta & Num, DnSta & Num=  ,4411.766, 2 ,4411.766, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   62.14   75.88
     1.5     1.5
   62.44   76.18
Pier Skew, UpSta & Num, DnSta & Num=  ,4449.97, 2 ,4449.97, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   62.96   75.88
     1.5     1.5
   63.26   76.18
Pier Skew, UpSta & Num, DnSta & Num=  ,4487.664, 2 ,4487.664, 2 , 0 , 0 , 0 ,,
     1.5     1.5
    62.8   75.87
     1.5     1.5
    63.1   76.17
Pier Skew, UpSta & Num, DnSta & Num=  ,4526.038, 2 ,4526.038, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   62.12   75.86
     1.5     1.5
   62.42   76.16
Pier Skew, UpSta & Num, DnSta & Num=  ,4563.732, 2 ,4563.732, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   58.41   75.86
     1.5     1.5
   58.71   76.16
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=88

Type RM Length L Ch R = 1 ,10534   ,251.7,254,137.1
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3128595.13     13943502.02      3129631.74     13940790.63
      3129737.13     13939775.66      3129721.44     13937291.62
#Sta/Elev= 30
1513.971   88.29 1556.42   84.09 2744.98   75.292780.297   69.282812.898   66.49
2863.836   73.293160.976   67.493228.894   75.193288.322   75.693424.157   68.09
3551.503   72.494089.072   62.924152.745   65.774165.904   62.184196.042      42
4263.621   41.664286.288   42.974351.999      634526.038   63.634551.932   57.24
4592.937   59.954593.361   65.814594.295   65.835127.959   62.295263.794   57.09
5594.893   69.495643.115   67.225736.501   71.756435.375   83.69 6947.22   80.49
#Mann= 6 , 1 , 0
1513.971      .1       02780.297     .14       04165.904    .055       0
4351.999     .14       05643.115      .1       05736.501     .99       0
#XS Ineff= 2 , 0
       0 4148.94   76.934634.112       0      77
Permanent Ineff=
       F       F
Bank Sta=4165.904,4351.999
XS Rating Curve= 0
Skew Angle= 31.9
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,10280.  ,351.4,512,573.5
BEGIN DESCRIPTION:
K100-00-00-S1_CYPRESSWOOD DR -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3128719.51      13943582.5      3129941.56     13940490.51
      3129815.09     13940161.68      3129890.46     13937252.62
#Sta/Elev= 30
  1490.4   83.39  1570.4   85.89  1710.4   84.88  1760.4   80.88  1820.4   83.62
  2340.4   81.19  3110.4   70.62  3390.4   72.91  3760.4   68.98  3790.4   71.27
  4310.4   69.86  4815.2   56.22  4855.2   64.52  4915.2   60.31 4918.65   52.64
 4936.18   43.59 4963.76   45.02  5000.8   41.47 5025.31    42.6  5095.2   62.79
  5327.5   63.85  5507.5   60.16  5547.5   55.79  5657.5   62.04  5877.5   61.54
  6227.5   69.83  6377.5   69.76  6557.5   76.48  7007.5   84.66  8077.5   82.66
#Mann= 4 ,-1 , 0
  1490.4      .1       0  2340.4     .14       0  4855.2    .055       0
  5095.2     .14       0
#XS Ineff= 2 , 0
         4341.21   76.42 5734.44           76.93
Permanent Ineff=
       F       F
Bank Sta=4855.2,5095.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,9768    ,872.5,1654,1560.7
BEGIN DESCRIPTION:
Cross Section XS04.3
END DESCRIPTION:
XS GIS Cut Line= 6
      3129157.98     13943646.57      3130423.32      13940183.6
      3130296.73     13940030.65      3130251.17     13939968.52
      3130211.59     13939927.89      3130239.96     13938212.82
#Sta/Elev= 30
  1082.3   87.94  1272.3   83.73  1402.3   85.28  1532.3    80.5  1592.3   83.22
  1842.3    80.1  2052.3   81.51  2522.3   74.39  3162.3   72.89  3412.3    66.4
  3592.3   69.78  3732.3   66.33  3942.3   67.24  4002.3    62.2  4242.3   66.34
  4542.3   62.05  4732.3   63.18  4799.2   55.19  4869.2   62.02 4915.19   62.16
 4945.99   45.59    5000    41.1 5039.44   42.49 5110.11   64.54  5401.5    62.4
  5481.5   57.65  5581.5   63.11  6001.5    67.3  6591.5   83.74  6816.8   86.57
#Mann= 6 ,-1 , 0
  1082.3      .1       0  1842.3     .14       0  3412.3     .05       0
  4542.3     .12       0 4915.19    .055       0 5110.11     .14       0
#XS Ineff= 2 , 0
       0    4100      76    5700       0      76
Permanent Ineff=
       F       F
Bank Sta=4915.19,5110.11
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,8114    ,1043.2,1081,1045.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X04
END DESCRIPTION:
XS GIS Cut Line= 4
       3129400.2     13943682.35      3130964.79     13939468.48
      3131228.66     13939085.09       3131494.4     13938698.97
#Sta/Elev= 30
   245.6    88.7   405.6    83.5   455.6    86.2   545.6      86   655.6    81.2
   775.6    84.2  1015.6    79.5  1090.4   81.33  1805.6      75  2055.6    77.2
  2285.6    72.4    2580   70.96  2625.6    68.5  2885.6    72.5  3115.6      67
  3215.6      70  3995.6      71  4125.6    66.2  4265.6    67.2  4419.6   63.15
  4615.6    65.7  4933.5   62.12  4952.4   54.39  4974.7   41.56  4999.3   39.84
  5024.7   41.93  5074.1      68    5130   78.21  5180.6    83.6  5674.7    88.3
#Mann= 6 ,-1 , 0
   245.6      .1       0  1090.4     .14       0    2580     .05       0
  4419.6     .14       0  4933.5    .055       0  5074.1     .14       0
Bank Sta=4933.5,5074.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,7033    ,992.6,1754,1638.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X03
END DESCRIPTION:
XS GIS Cut Line= 4
      3130007.84     13943916.73      3131563.11     13940333.53
      3132077.36     13939696.44      3132612.93     13939696.79
#Sta/Elev= 30
   671.6    88.8   871.6    83.7  1081.6    84.1  1131.6      81  1331.6    82.7
  1571.6    78.9  1921.6    78.2  1961.6    80.9  2091.6    78.6  2241.6    81.4
  3191.6    73.2  3231.6    73.6  3291.6    81.7  3401.6    73.6  3521.6    70.5
    3650   69.64  4091.6    60.7  4261.6    61.6  4351.6      55  4371.9   56.74
  4431.6    63.7  4914.4   60.93  4923.8   54.83  4961.9   43.75  4987.1   32.44
    5013   34.63  5088.2   63.99  5337.8    68.1  5686.5    82.7  5932.1    88.3
#Mann= 6 ,-1 , 0
   671.6      .1       0  3521.6    .026       0    3650     .05       0
  4371.9     .14       0  4914.4    .055       0  5088.2     .14       0
#Block Obstruct= 2 ,-1
    3949 4576.28    64.5    9000    9100      10
Bank Sta=4914.4,5088.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,5279    ,1417.7,1291,944.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X02
END DESCRIPTION:
XS GIS Cut Line= 4
      3130216.17     13943977.49      3131470.09     13941478.41
      3132270.37     13941311.51        3133651.     13940352.62
#Sta/Elev= 30
  1658.5      88  1838.5    84.4  2058.5    85.1  2108.5    80.9    2221   83.14
  2688.5    78.5  3588.5    76.5  3648.5    79.5  3858.5    76.3  3958.5    80.5
  4058.5    79.6  4158.5    69.7  4188.5    69.2  4248.5    75.1  4298.5    69.3
  4368.5    71.7  4714.7   63.15  4911.6   58.61  4940.8   53.26  4961.8    41.4
  5071.1   44.45  5087.3   48.08  5105.4   60.93  5114.5    56.3  5244.5    61.7
    5612    57.3    5722    61.9    6082    66.1    6642    82.1    6953    87.3
#Mann= 5 ,-1 , 0
  1658.5      .1       0    2221     .05       0  4714.7     .14       0
  4911.6    .055       0  5105.4     .14       0
#XS Ineff= 2 , 0
       0  4368.5    71.7               0
Permanent Ineff=
       F       F
Bank Sta=4911.6,5105.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,3988    ,0,0,0
BEGIN DESCRIPTION:
Cross Section K100-00-00-X01
END DESCRIPTION:
XS GIS Cut Line= 4
      3132274.96     13944722.14      3132939.84     13942220.14
      3133425.66     13941420.42      3133707.33     13940429.07
#Sta/Elev= 30
  2057.4    86.4  2237.4    84.4  2427.4    78.6  2557.4    81.9  3467.4      77
  3587.4      73  3637.4    75.5  3837.4    76.2  4267.4    72.9  4377.4    66.8
  4517.4    63.1  4567.4    58.1  4648.8   56.78  4796.2    46.1  4856.2    55.9
  4943.9   53.78  4965.4   42.19  5001.1   39.16  5034.6   41.49  5062.1   51.46
  5076.2   61.16  5146.2    61.7  5216.2    54.1  5306.2    53.5  5386.2    60.6
  5516.2    67.7    6052    72.1    6292    78.4    6462      86  6612.5    88.1
#Mann= 4 ,-1 , 0
  2057.4     .05       0  4648.8     .14       0  4943.9    .055       0
  5076.2     .14       0
#Block Obstruct= 2 ,-1
    4583  4884.7   56.86    5144    5420   61.76
Bank Sta=4943.9,5076.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Chan Stop Cuts=-1
