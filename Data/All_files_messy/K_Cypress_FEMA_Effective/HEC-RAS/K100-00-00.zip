HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,124694  ,100.5,101,105.9
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
     3045958.502    13921422.983     3048761.401    13921017.015
     3049667.031    13920239.345     3051448.441    13917978.325
#Sta/Elev= 30
  1749.7  129.65  2299.7  128.15  2539.7  124.85  3029.7  126.95  3579.7  124.15
  3879.7  125.95  4029.7  122.35  4239.7  123.15  4569.7  117.35  4603.5  121.05
  4862.2  117.06  4976.7  103.86  4998.6   95.96  5014.3   98.34  5023.8  105.72
  5131.9  115.63  5373.5  118.25  5663.5  116.05  6009.6  119.25  6349.6  118.45
  6459.6  121.25  6669.6  119.65  6859.6  122.25  7079.6  119.05  7149.6  122.65
  7289.6  124.75  7419.6  122.75  7479.6  126.55  7709.6  127.95  8636.1  125.85
#Mann= 6 ,-1 , 0
  1749.7     .99       0  4029.7     .14       0  4862.2     .06       0
  5131.9     .06       0  5373.5     .14       0  6669.6     .99       0
#XS Ineff= 2 , 0
       0  4821.7     124  5179.5       0     124
Permanent Ineff=
       F       F
Bank Sta=4862.2,5131.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,124593. ,207.8,496,226.9
BEGIN DESCRIPTION:
K100-00-00-SJONES_JONES RD -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3046279.45      13921392.2      3048829.36     13921091.15
      3049734.99     13920313.48       3051516.4     13918052.46
#Sta/Elev= 30
  2000.5  127.04  2080.5  129.01  2440.5  127.68  2510.5  125.08  2550.5  127.17
  3430.5  125.01  3540.5  126.96  4210.5  119.14  4300.5  123.18  4400.5  121.38
  4430.5  117.43  4748.1  118.44  4880.2  115.53  4976.7  103.75  4998.6   95.85
 5013.14   98.05 5021.94  104.32  5138.1  116.26  5658.1  115.97  5758.1   110.7
  5881.8  117.75  6051.8  119.07  6911.8  119.53  7071.8   123.5  7241.8  122.28
  7321.8  126.86  7581.8  126.18  7731.8  129.52  7991.8  125.47  8640.3  127.21
#Mann= 5 ,-1 , 0
  2000.5      .1       0  4400.5     .12       0  4880.2     .06       0
  5138.1     .12       0  6051.8      .1       0
#XS Ineff= 2 , 0
         4399.53  124.09 5910.95          123.95
Permanent Ineff=
       F       F
Bank Sta=4880.2,5138.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,124097  ,557.2,660,607.4
BEGIN DESCRIPTION:
Cross Section XS35.5
END DESCRIPTION:
XS GIS Cut Line= 4
      3045930.99      13921430.2      3049505.32     13921173.98
      3049570.04     13921078.29      3051141.46     13918612.12
#Sta/Elev= 30
  1334.8     130  1614.8   126.5  2154.8   127.9  2214.8   125.2  3214.8   126.9
  3854.8   121.2  4034.8   124.1  4084.8   120.5  4164.8   116.9  4484.8     114
  4644.8   117.9  4862.2  116.39  4976.7  103.19  4998.6   95.29  5014.3   97.67
  5023.8  105.05  5073.8   110.8  5593.8   118.1  6123.8   119.5  6243.8   122.5
  6303.8   119.1  6393.8   121.8  6623.8   119.2  6733.8   122.5  6953.8   120.1
  7143.8   125.3  7283.8   123.8  7333.8   127.2  7713.8   129.4  7958.1   125.5
#Mann= 7 ,-1 , 0
  1334.8     .99       0  3214.8      .1       0  4084.8     .14       0
  4862.2     .06       0  5073.8     .14       0  6123.8      .1       0
  6733.8     .99       0
#XS Ineff= 2 , 0
         4032.12  123.91 6237.85          122.97
Permanent Ineff=
       F       F
Bank Sta=4862.2,5073.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,123437. ,86.9,93,87.3
BEGIN DESCRIPTION:
K100-00-00-S17A_PIPELINE -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3046276.36      13921435.4      3049690.12     13921683.67
      3050228.09     13921507.61      3051216.01     13918778.61
#Sta/Elev= 30
  1337.3  128.53  1837.3     125  1957.3  127.65  2867.3  126.82  3067.3  121.34
  3107.3  124.07  3447.3  123.08  3557.3  125.47  4137.3  122.22  4237.3  116.42
  4667.3  115.77  4930.1  116.21  4960.1  103.23 4976.92  100.31 4978.71    97.7
 5004.61   94.58 5020.48   96.49  5040.1  108.48  5050.1  111.63  5080.1  117.54
  5416.1  114.64  5536.1   118.6  6666.1  119.77  7106.1  118.91  7206.1  122.15
  7416.1  119.37  7546.1  125.28  7716.1  123.39  7896.1  127.65  8228.4  127.85
#Mann= 5 ,-1 , 0
  1337.3      .1       0  4667.3     .14       0  4930.1     .06       0
  5080.1     .14       0  6666.1      .1       0
Bank Sta=4930.1,5080.1
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,123344  ,32.7,28,32.5
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3045872.82     13921428.33      3049736.45     13921760.89
      3050274.43     13921584.83      3051262.34     13918855.83
#Sta/Elev= 30
 808.171  130.711465.162  128.311576.095  125.311659.364  127.811705.624  125.21
1899.918  128.11 2603.17  126.812769.708  121.813195.212  125.913741.085  122.31
3805.943  116.814460.898  117.014549.293  115.694577.882  111.964582.601  106.59
4606.008   99.094607.489   96.194628.954   94.48 4644.59   96.064676.972  112.37
4695.939  115.184919.803  114.415123.349  118.016196.685  118.116298.365  120.81
6640.785  119.016862.835  121.716918.348  119.117288.339  128.017605.131  127.21
#Mann= 7 ,-1 , 0
 808.171     .99       02769.708     .12       03741.085     .14       0
4577.882     .06       04695.939     .06       04919.803     .14       0
6298.365     .99       0
Bank Sta=4577.882,4695.939
XS Rating Curve= 0
Skew Angle= 22.3
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,123333.5,,,
BEGIN DESCRIPTION:
PL1_K100-00-00-S17A
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,1,2.6,22.3, 60, 60, , , .95, 0, ,,,
 808.171 919.196 947.0451030.2211141.2461465.1621576.0951659.3641705.6241751.977
1899.9182297.7582436.6322501.304 2603.172723.4472769.6152815.8763000.9183047.271
3093.5313121.2883148.9513195.3043472.7753546.8843741.1783805.9434333.3124388.732
4460.8064519.1314549.2934571.831 4572.714574.8294697.7894738.4614919.8955021.668
5123.3495326.9875511.9376196.6856279.8616344.7186474.248 6529.766640.7856862.835
6918.3487066.3827131.0547223.6677288.3397371.7017473.4747519.6427547.3987605.131
   130.7     129   129.6   127.1   129.4   128.3   125.3   127.8  125.21   127.5
   128.1   126.2     127   124.9   126.8   125.2   121.8     124   125.1   123.5
  124.61  123.41  125.51   125.9   122.9   123.5   122.3   116.8   116.6     115
     117  116.59  115.69  112.71  113.87  124.16  124.31  116.42   114.4   114.9
     118   117.2     119   118.1   120.9   119.4   119.7     121     119   121.7
   119.1   121.1     124   124.3     128   128.7   127.8   125.6  127.21   127.2
   130.7     129   129.6   127.1   129.4   128.3   125.3   127.8   125.2   127.5
   128.1   126.2     127   124.9   126.8   125.2   121.8     124   125.1   123.5
   124.6   123.4   125.5   125.9   122.9   123.5  122.29   116.8   116.6     115
     117  116.58  115.68   112.7  112.59  123.16  123.31  116.41   114.4   114.9
     118   117.2     119   118.1   120.9   119.4   119.7     121     119   121.7
   119.1   121.1     124   124.3     128   128.7   127.8   125.6   127.2   127.2
 808.171 919.196 947.0451030.2211141.2461465.1621576.0951659.3641705.6241751.977
1899.9182297.7582436.6322501.304 2603.172723.4472769.6152815.8763000.9183047.271
3093.5313121.2883148.9513195.3043472.7753546.8843741.1783805.9434333.3124388.732
4460.8064519.1314549.2934571.831 4572.714574.8294697.7894738.4614919.8955021.668
5123.3495326.9875511.9376196.6856279.8616344.7186474.248 6529.766640.7856862.835
6918.3487066.3827131.0547223.6677288.3397371.7017473.4747519.6427547.3987605.131
   130.7     129   129.6   127.1   129.4   128.3   125.3   127.8  125.21   127.5
   128.1   126.2     127   124.9   126.8   125.2   121.8     124   125.1   123.5
  124.61  123.41  125.51   125.9   122.9   123.5   122.3   116.8   116.6     115
     117  116.59  115.69  112.71  113.87  124.16  124.31  116.42   114.4   114.9
     118   117.2     119   118.1   120.9   119.4   119.7     121     119   121.7
   119.1   121.1     124   124.3     128   128.7   127.8   125.6  127.21   127.2
   130.7     129   129.6   127.1   129.4   128.3   125.3   127.8   125.2   127.5
   128.1   126.2     127   124.9   126.8   125.2   121.8     124   125.1   123.5
   124.6   123.4   125.5   125.9   122.9   123.5  122.29   116.8   116.6     115
     117  116.58  115.68   112.7  112.59  123.16  123.31  116.41   114.4   114.9
     118   117.2     119   118.1   120.9   119.4   119.7     121     119   121.7
   119.1   121.1     124   124.3     128   128.7   127.8   125.6   127.2   127.2
Pier Skew, UpSta & Num, DnSta & Num=  ,4580.343, 2 ,4580.343, 2 , 0 , 0 , 0 ,,
     1.3     1.3
  107.42  124.17
     1.3     1.3
  107.42  124.17
Pier Skew, UpSta & Num, DnSta & Num=  ,4614.761, 2 ,4614.761, 2 , 0 , 0 , 0 ,,
     1.3     1.3
   94.49  124.21
     1.3     1.3
   94.49  124.21
Pier Skew, UpSta & Num, DnSta & Num=  ,4651.399, 2 ,4651.399, 2 , 0 , 0 , 0 ,,
     1.3     1.3
   99.07  124.25
     1.3     1.3
   99.07  124.25
Pier Skew, UpSta & Num, DnSta & Num=  ,4688.038, 2 ,4688.038, 2 , 0 , 0 , 0 ,,
     1.3     1.3
  112.92   124.3
     1.3     1.3
  112.92   124.3
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=130.71

Type RM Length L Ch R = 1 ,123316  ,87.5,104,115.3
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3045875.32     13921454.34      3049743.01     13921787.26
      3050294.13     13921606.89      3051285.36     13918868.73
#Sta/Elev= 30
 808.171  130.681465.162  128.281576.095  125.281659.364  127.781705.624  125.18
1899.918  128.08 2603.17  126.782769.708  121.783195.212  125.883741.085  122.28
3805.943  116.784460.898  116.984549.293  115.664577.882  111.934582.601  106.56
4606.008   99.064607.489   96.164628.954   94.45 4644.59   96.034676.972  112.34
4695.939  115.154919.803  114.385123.349  117.986196.685  118.086298.365  120.78
6640.785  118.986862.835  121.686918.348  119.087288.339  127.987605.131  127.18
#Mann= 7 ,-1 , 0
 808.171     .99       02769.708     .12       03741.085     .14       0
4577.882     .06       04695.939     .06       04919.803     .14       0
6298.365     .99       0
Bank Sta=4577.882,4695.939
XS Rating Curve= 0
Skew Angle= 22.3
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,123212. ,1438.8,1126,1187.5
BEGIN DESCRIPTION:
K100-00-00-S17A_PIPELINE -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3045946.22      13921529.4      3049813.91     13921862.38
      3050365.03     13921682.02      3051356.26     13918943.86
#Sta/Elev= 30
   855.8  129.01  1415.8  126.15  1715.8  127.85  1785.8  125.43  1875.8  127.98
  2205.8  125.11  2535.8  127.57  2825.8  125.66  2895.8  121.63  2945.8  124.27
  3215.8  124.12  3765.8  125.03  3975.8  117.79  4265.8  117.42  4947.8  114.15
 4997.42   99.09 4998.87   96.37 5019.87   94.27 5035.26   95.89  5067.8  113.26
  5077.8  114.61  5617.7  118.75  6687.7  118.18  6797.7  120.73  7337.7  119.11
  7467.7  121.74  7577.7  118.69  7617.7   121.8  7927.7  126.31  8229.7  125.53
#Mann= 6 ,-1 , 0
   855.8      .1       0  3215.8     .12       0  4265.8     .14       0
  4947.8     .06       0  5077.8     .14       0  6797.7      .1       0
Bank Sta=4947.8,5077.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,122086  ,1339.5,1089,132.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X35
END DESCRIPTION:
XS GIS Cut Line= 4
       3049985.2     13924640.82      3050630.77     13922479.15
      3051276.34     13922009.64      3052675.07     13919192.61
#Sta/Elev= 30
  2417.6   130.6  2607.6   126.9  2877.6   128.9  3447.6   121.6  3557.6   125.1
  3817.6   121.3  4425.4  118.21  4467.6     114  4713.6   115.5  4834.7  109.17
  4956.7  111.69  4982.3   95.55  4994.6   92.32  5018.2   96.15  5031.5  109.24
  5049.1  115.77  5203.6   116.7  5283.6   113.6  5343.6     118  5453.6   118.6
  5631.9   114.4  5751.9   118.3  6251.9   114.9  6591.9   117.7  6621.9   115.5
  6691.9   119.1  6761.9   117.7  6921.9     122  7511.9     126    8617   128.6
#Mann= 4 ,-1 , 0
  2417.6     .99       0  4425.4     .14       0  4956.7     .06       0
  5049.1     .14       0
Bank Sta=4956.7,5049.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,120997  ,436.74,745.51,540.09
BEGIN DESCRIPTION:
Cross Section XS35.1
END DESCRIPTION:
XS GIS Cut Line= 6
       3051599.5       13924383.      3051927.23     13923057.24
      3051829.92     13922667.34      3051755.18     13922420.14
      3051556.97     13921737.92      3052747.71     13919254.38
#Sta/Elev= 30
  3074.7     127  3194.7   127.3  3234.7   123.8  3304.7   122.6  3524.7   124.6
  3774.7   119.4  4384.7   121.3  4460.4   118.2  4540.4   119.6  4720.4   116.5
  4830.4   106.4  4862.3   110.7  4969.6  104.74  4982.3   95.32  4994.6   92.09
  5018.2   95.92  5031.5  109.01  5140.6   114.7  5240.6   113.6  5320.6   118.2
  5570.6   114.2  5750.6   116.3    6311   117.4    6341   113.3    6381     120
    6461   119.1    6481   116.3    6581   119.3    7371     126  8565.2   128.4
#Mann= 4 ,-1 , 0
  3074.7     .99       0  4384.7     .12       0  4862.3     .06       0
  5140.6     .12       0
#XS Ineff= 2 , 0
         3515.62  124.11
Permanent Ineff=
       F       F
Bank Sta=4862.3,5140.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,120252  ,184.68,125.27,132.59
XS GIS Cut Line= 5
 3051741.434064713924301.3397758 3052339.116430913922685.2875591
 3052348.793337113922167.5730815 3052177.028253413921686.1470019
 3052698.147798813919463.3069865
#Sta/Elev= 30
 2666.27  126.97 3593.86  119.29 3881.74  121.28 4105.64  122.31 4169.61  115.31
  4867.7  107.35    4975  104.74  4987.7   95.32    5000   91.94  5023.6   95.92
  5036.9  109.01    5146  118.05 5209.71  120.73 5305.26  109.94 5706.85  111.13
 5735.64  118.49 5765.64  118.49 5805.64  128.49 5818.83  128.76 5865.05  128.43
 5911.27  120.09 6003.71   118.2 7005.15  127.64 7066.78  125.51 7128.41  118.46
 7267.07  114.01 7436.54  124.38 7513.57  114.45 7559.79  127.15 7701.37  128.41
#Mann= 4 ,-1 , 0
 2666.27     .99       0 3881.74     .12       0  4867.7     .06       0
    5146     .12       0
#XS Ineff= 2 , 0
 2666.27 3467.45  124.11         2666.27
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
 5209.71 5735.64     118 7005.15 7590.61  127.64
Bank Sta=4867.7,5146
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,120126  ,489.48,550.22,561.62
XS GIS Cut Line= 5
  3051851.66584113924248.8357938 3052465.398897713922574.2313877
 3052464.699744813922141.1621072 3052322.072556213921689.8029871
   3052763.3314213919356.1430929
#Sta/Elev= 30
 2626.09     126 2705.97   128.8 3776.34  120.46 3952.07  121.46 4015.97  114.57
 4175.73  113.66 4367.44  119.24 4368.58   122.7 4376.85     123 4662.03  121.22
 4712.26  119.47  4860.5  113.97  4864.7  106.43 4889.88106.8041  4899.7  106.95
  4937.7  102.99  4951.4   96.37    5000    91.8  5026.1   96.92  5035.1  112.18
 5078.66112.8063 5094.39  116.82 5157.31   119.7 5298.89  110.91 5468.71  119.31
 5987.75  118.53  7346.4  128.15  7392.2  115.07 7453.26   127.6 7691.06  129.09
#Mann= 6 ,-1 , 0
 2626.09     .99       0 3776.34     .12       0 4662.03     .04       0
 4712.26      .1       0 4889.88     .06       0 5078.66     .12       0
#XS Ineff= 2 , 0
 2626.09  3588.9  127.39         2626.09
Permanent Ineff=
       F       F
#Block Obstruct= 4 ,-1
                                                 5157.31 5483.97  119.32
  7346.4 7453.26   127.6
Bank Sta=4899.7,5035.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,119576  ,1016.7,1075,1123.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X35A
END DESCRIPTION:
XS GIS Cut Line= 4
       3052029.5     13924298.48      3052919.61     13922117.24
       3052870.7     13921373.85      3052802.23     13919398.02
#Sta/Elev= 30
  2320.1   131.7  2450.1   125.4  3490.1   121.7  3570.1     117  3940.1   116.4
 4091.32  122.48 4519.19  122.66 4780.81  118.61 4881.02   106.5 4900.91  109.27
  4906.1  106.95  4916.6     104  4944.1  102.99  4957.8   96.37  5006.4    91.8
  5032.5   96.92  5041.5  112.18    5276   115.7    5461   114.3    5511   118.2
    5711   118.1    6081   124.2    6341   122.8    6611   126.8    7101   128.4
    7151   114.9    7191   127.2    7201     128    7271   126.2    7398   128.3
#Mann= 7 ,-1 , 0
  2320.1     .99       0  3490.1     .12       0 4519.19     .04       0
 4780.81      .1       0  4944.1     .06       0  5041.5     .12       0
    7398     .99       0
#XS Ineff= 2 , 0
         4015.62  127.39
Permanent Ineff=
       F       F
#Block Obstruct= 3 ,-1
  4003.5 4414.87     150  7101.8  7201.1     128  7201.7  7201.9     115
Bank Sta=4906.1,5041.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,118501. ,94.3,102,128.4
BEGIN DESCRIPTION:
K100-00-00-S17_SH249 -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3052154.59      13924239.2      3053866.83     13921737.41
      3053888.23     13921589.84      3055115.46     13918975.63
#Sta/Elev= 30
  1889.8  126.23  2289.8  127.42  2729.8  121.19  3819.8  123.07  4039.8  119.49
  4059.8  120.18 4063.78  123.34 4450.92   123.4 4505.38  117.38 4589.33  114.59
 4611.77  108.41 4730.95  104.87  4739.8  108.87  4931.5  112.61  4951.5  110.52
  4971.5  103.45 4984.79   86.93 5003.02   79.43 5023.56   89.65  5031.5  102.05
  5061.5  114.68  5130.6  118.07  5420.6  114.37  5460.6  116.32  5500.6  122.97
  5990.6  122.01  6600.6  131.62  6830.6  128.59  7070.6  130.12  7958.5  128.18
#Mann= 6 ,-1 , 0
  1889.8      .1       0 4450.92     .04       0  4739.8      .1       0
  4931.5     .06       0  5061.5      .1       0  7070.6     .12       0
#XS Ineff= 2 , 0
          4381.4  127.04
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
 3421.39 3680.83     150 3736.36 3947.48     150
Bank Sta=4931.5,5061.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,118399  ,323.5,335,328.3
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3052075.02     13924500.44      3053336.82     13922866.95
      3054148.67     13921370.41      3055420.25     13919071.79
#Sta/Elev= 30
  1604.5  128.62  1734.6  126.12  1844.6  127.42  1914.6  124.72  1974.6  127.62
  2214.6  127.12  2944.6  120.92  3798.7  119.92  4278.7  120.22  4396.5  113.97
  4604.6     115    4823  107.49  4922.6   97.43  4983.2   86.42  5002.7   78.26
  5022.5   88.69  5108.2  116.26  5471.2  114.62  5511.2  118.12  5571.2  116.92
  5661.2  118.42  5701.2  122.82  5783.9  122.49  5851.2  119.52  6551.2  125.92
  6591.2  129.12  6721.2  125.72  6961.2  128.42  7521.2  126.32  7998.1  128.52
#Mann= 5 ,-1 , 0
  1604.5     .99       0  3798.7      .1       0  4604.6     .06       0
  5108.2     .12       0  5783.9     .99       0
#XS Ineff= 2 , 0
       0 4591.15  126.52 5156.25       0  126.65
Permanent Ineff=
       F       F
Bank Sta=4604.6,5108.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,118237  ,,,
BEGIN DESCRIPTION:
SH249
Structure ID: K100-00-00-S17
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,304,2.6,0, 60, 60, , , .95, 0, ,,,
  1604.5  1734.6  1736.1  1844.6  1914.6  1974.6  1994.6  2104.6  2214.6  2524.6
  2554.6  2674.6  2734.6  2774.6  2966.1  3056.1  3403.1 3855.29  3855.4  3963.2
  4258.7  4278.7  4388.7  4396.5 4603.31  4603.4  4603.5  5121.7 5141.59  5141.7
  5141.8  5441.7 5441.81  5471.2  5511.2  5571.2  5661.2  5701.2  5781.2  5811.2
  5851.2  6193.9  6213.9  6353.9  6551.2  6591.2  6721.2  6843.9  6911.2  6961.2
  7051.2  7151.2  7191.2  7381.2  7503.9  7641.2  7681.2  7963.9  7973.3  7998.1
   128.5     126   129.4  129.32  129.27  129.22  129.21  128.82  128.39  127.52
  127.38   127.5   127.5   127.5   127.5   122.8   123.4  144.02  146.62  147.29
  146.68  146.57  145.56  145.47  142.53  142.53  142.53  134.64  134.21  134.21
  134.21  130.39  127.79  127.89     128  128.15  128.38  128.49  128.69  129.33
  130.26   138.2   137.9   124.5  125.81  129.01  126.34   125.8  128.11  128.31
  126.71  126.71  128.11  126.72   145.2  141.89  140.92   134.1   133.7   128.4
   128.5     126  126.02   127.3   124.6   127.5   126.4   126.1     127   123.4
   124.1   122.3   123.3   121.7  121.19  121.37  119.61  120.45  120.45  120.81
   118.9   120.1   115.6  113.85  114.87  127.23  127.23  119.34  118.91  116.57
  116.56  115.38  115.38   114.5     118   116.8   118.3   122.7   122.6     120
   119.4  123.15  123.51  124.12   125.8     129   125.6  125.76   128.1   128.3
   126.7   126.7   128.1   126.7  126.23   128.4   126.9  127.94  128.06   128.4
  1604.5  1734.6  1736.1  1844.6  1914.6  1974.6  1994.6  2104.6  2214.6  2524.6
  2554.6  2674.6  2734.6  2774.6  2966.1  3056.1  3403.1 3855.29  3855.4  3963.2
  4258.7  4278.7  4388.7  4396.5 4603.31  4603.4  4603.5  5121.7 5141.59  5141.7
  5141.8  5441.7 5441.81  5471.2  5511.2  5571.2  5661.2  5701.2  5781.2  5811.2
  5851.2  6193.9  6213.9  6353.9  6551.2  6591.2  6721.2  6843.9  6911.2  6961.2
  7051.2  7151.2  7191.2  7381.2  7503.9  7641.2  7681.2  7963.9  7973.3  7998.1
   128.5     126   129.4  129.32  129.27  129.22  129.21  128.82  128.39  127.52
  127.38   127.5   127.5   127.5   127.5   122.8   123.4  144.02  146.62  147.29
  146.68  146.57  145.56  145.47  142.53  142.53  142.53  134.64  134.21  134.21
  134.21  130.39  127.79  127.89     128  128.15  128.38  128.49  128.69  129.33
  130.26   138.2   137.9   124.5  125.81  129.01  126.34   125.8  128.11  128.31
  126.71  126.71  128.11  126.72   145.2  141.89  140.92   134.1   133.7   128.4
   128.5     126  126.02   127.3   124.6   127.5   126.4   126.1     127   123.4
   124.1   122.3   123.3   121.7  121.19  121.37  119.61  120.45  120.45  120.81
   118.9   120.1   115.6  113.85  114.87  127.23  127.23  119.34  118.91  116.57
  116.56  115.38  115.38   114.5     118   116.8   118.3   122.7   122.6     120
   119.4  123.15  123.51  124.12   125.8     129   125.6  125.76   128.1   128.3
   126.7   126.7   128.1   126.7  126.23   128.4   126.9  127.94  128.06   128.4
Pier Skew, UpSta & Num, DnSta & Num=  ,4722.3, 2 ,4722.3, 2 , 0 , 0 , 0 ,,
     3.5     3.5
   109.6  126.47
     3.5     3.5
  113.18  130.05
Pier Skew, UpSta & Num, DnSta & Num=  ,4823, 2 ,4823, 2 , 0 , 0 , 0 ,,
     3.5     3.5
  106.19  124.96
     3.5     3.5
  109.77  128.54
Pier Skew, UpSta & Num, DnSta & Num=  ,4922.6, 2 ,4922.6, 2 , 0 , 0 , 0 ,,
     3.5     3.5
   95.99  123.39
     3.5     3.5
   99.57  126.97
Pier Skew, UpSta & Num, DnSta & Num=  ,5022.5, 2 ,5022.5, 2 , 0 , 0 , 0 ,,
     3.5     3.5
   86.85  121.97
     3.5     3.5
   90.42  125.55
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=129.12

Type RM Length L Ch R = 1 ,118064  ,111.9,114,122.8
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3052316.43     13924731.98      3053579.21     13923097.22
      3054391.79     13921599.33      3055663.33     13919300.79
#Sta/Elev= 30
  1604.5  128.62  1844.6  127.42  1914.6  124.72  1974.6  127.62  2214.6  127.12
  2944.6  120.92  3798.7  119.92  4278.7  120.22  4396.5  113.97  4604.6     115
  4650.3  116.76    4823  111.03  4922.6  100.97  4983.2   89.96  5002.7    81.8
  5022.5   92.23  5108.2  116.26  5471.2  114.62  5511.2  118.12  5571.2  116.92
  5661.2  118.42  5701.2  122.82  5783.9  122.49  5851.2  119.52  6551.2  125.92
  6591.2  129.12  6721.2  125.72  6961.2  128.42  7521.2  126.32  7998.1  128.52
#Mann= 6 ,-1 , 0
  1604.5     .99       0  3798.7      .1       0  4604.6     .06       0
  4650.3     .06       0  5108.2     .12       0  5783.9     .99       0
#XS Ineff= 2 , 0
       0 4597.22  125.76  5151.5       0   127.6
Permanent Ineff=
       F       F
Bank Sta=4650.3,5108.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,117950. ,791.6,1086,968.8
BEGIN DESCRIPTION:
K100-00-00-S17_SH249 -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3052425.65      13924763.8      3053688.43     13923129.07
      3054501.01     13921631.18      3055758.76     13919285.37
#Sta/Elev= 30
  1616.8   128.1  1746.8  128.26  1796.8  126.07  1916.8  128.42  2206.8  127.29
  2506.8  124.81  2546.8  122.47  2606.8  125.14  3056.8   121.8  3842.5  123.43
  4382.5  116.47  4452.5  114.63  4492.5  110.04  4862.5  110.97  4892.5  117.76
  4912.5  118.83 5002.67   82.71 5023.07    92.8  5032.5     101  5072.5  112.24
  5252.5  113.38  5352.5  117.66  5816.6  115.64  6026.6  119.87  6096.6  118.24
  6456.6  122.74  6566.6   120.4  6756.6  124.71  7296.6  121.56  8048.3  128.95
#Mann= 6 ,-1 , 0
  1616.8     .14       0  4492.5    .026       0  4862.5     .14       0
  4912.5     .06       0  5072.5     .14       0  5816.6      .1       0
#XS Ineff= 2 , 0
         4366.43  125.88 5337.27          127.43
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
 4410.56 4895.98  114.77
Bank Sta=4912.5,5072.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,116864  ,1101.3,1779,1844.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X34B
END DESCRIPTION:
XS GIS Cut Line= 4
      3052997.86     13924503.89      3055394.29     13921941.17
      3055051.94     13921099.98      3055834.45     13919280.65
#Sta/Elev= 30
   971.4   131.2  1241.4   123.4  1481.4   125.8  2541.4   120.9  2961.4   123.1
  3421.4   115.2  4091.4   114.3  4151.4   109.5  4311.4   109.6  4431.4   115.8
    4520   116.5    4580   109.8    4710   113.5    4760   116.8    4810   108.7
    4864   109.9  4888.4  105.63  4935.2  107.81  4984.9   92.31  5002.4   91.35
  5015.2   92.38  5036.6  110.91  5075.2  106.94  5200.9  108.92    5310     119
  5468.2   115.8  5938.2   119.6  6088.2   124.1  6578.2   122.2  7368.7   130.9
#Mann= 8 ,-1 , 0
   971.4     .14       0  4091.4    .026       0  4431.4     .14       0
    4520    .026       0    4710     .14       0  4935.2     .06       0
  5036.6     .12       0  5200.9      .1       0
#XS Ineff= 2 , 0
         2916.67  125.38 5326.39           125.6
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
    3328    3329     100    3330  4755.2   116.8
Bank Sta=4935.2,5036.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,115085  ,740,1957,1501.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X34
END DESCRIPTION:
XS GIS Cut Line= 4
      3054200.96     13923848.54      3056470.23     13922244.39
      3056870.89     13921676.81      3057526.62     13920747.85
#Sta/Elev= 30
  1670.5   135.9  1720.6   136.5  1780.6   125.1  1830.6   122.3  2150.6   118.2
  3740.6   117.3  4060.6   115.6  4100.6   109.7  4190.6   109.4  4220.6     110
  4240.6   115.9  4499.6   114.6  4529.6     110  4729.6     110  4759.6   113.6
  4779.6   117.6  4819.6   119.8  4879.6   112.8  4899.6   108.2    4903   104.9
    4914  104.57    4933    96.9    5012   90.71  5018.6   96.13  5052.8  113.39
  5362.2  120.14  5764.4   127.8  5994.4   127.4  6044.4   125.1  6281.4   128.5
#Mann= 9 ,-1 , 0
  1670.5     .99       0  3740.6     .14       0  4060.6    .026       0
  4240.6     .14       0  4499.6    .026       0  4759.6     .14       0
  4819.6     .06       0  5052.8     .12       0  5362.2      .1       0
#Block Obstruct= 2 ,-1
  4009.7  4780.8   117.5    4781    4782     100
Bank Sta=4819.6,5052.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,113128  ,1529.9,1324,685.5
BEGIN DESCRIPTION:
Cross Section XS34.5
END DESCRIPTION:
XS GIS Cut Line= 6
       3054369.9      13924225.6      3055999.07     13922997.86
      3057136.24      13923148.3      3057408.84     13923194.84
      3057532.07     13923216.21      3058394.78     13921055.56
#Sta/Elev= 30
  1616.6   124.7  1896.6   125.5  2196.6   118.3  2456.6   116.4  2826.6   117.2
  3096.6   114.2  3766.6     117  3856.6   116.5  3896.6   109.4  4006.6   110.3
  4036.6   115.4  4266.6   116.6  4356.6   113.9  4386.6   109.4  4823.7   111.4
  4843.7   116.6  4879.6  112.95    4914  104.72    4933   97.05    5012   90.86
  5018.6   96.28  5063.7   117.3  5073.7   118.3    5125   116.2    5149     120
    6096     120  6155.3   116.2  6305.3   118.1  6785.3   123.1  7531.8   126.5
#Mann= 9 ,-1 , 0
  1616.6     .99       0  3766.6     .14       0  4356.6    .026       0
  4823.7     .14       0  4843.7     .06       0  5073.7     .14       0
  6155.3     .08       0  6305.3      .1       0  6785.3     .99       0
#XS Ineff= 2 , 0
                         6434.57          119.66
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
    3766 4843.71   116.6
Bank Sta=4843.7,5073.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,111804  ,523.6,271,67.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X34A
END DESCRIPTION:
XS GIS Cut Line= 4
      3056137.67     13925169.02       3057692.9     13924005.04
        3057957.     13923946.35      3058837.32     13921383.64
#Sta/Elev= 30
  2909.8   125.8  3789.8   122.1  4279.8     111  4689.8   115.4  4759.8   114.2
  4789.8     109  4852.4   104.2  4872.7  106.36    4942  105.98  4965.7   98.72
  4972.1   93.85  5014.4   90.97  5022.1   92.54  5022.5    98.7  5056.7  113.39
  5092.4   111.6  5122.4     108  5232.9   107.1    5466     112    5506     120
    6350     120    6390   115.4  6402.9   116.6  6422.9   114.2  6542.9     116
  6962.9   120.5  7072.9   123.9  7142.9   122.6  7242.9   126.9  7832.6   126.9
#Mann= 7 ,-1 , 0
  2909.8     .14       0    4942     .06       0  5056.7     .14       0
  5092.4     .06       0    5506     .14       0  6402.9     .08       0
  6542.9     .99       0
#XS Ineff= 2 , 0
       0  4689.8   115.4    5073       0   113.8
Permanent Ineff=
       F       F
Bank Sta=4942,5056.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,111533. ,128.2,155,163.1
BEGIN DESCRIPTION:
K100-00-00-S16_CUTTEN/SCHROEDER -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3056402.52      13925972.8      3057676.58     13924763.04
      3058016.14     13923967.19      3058896.76     13921453.81
#Sta/Elev= 30
  2628.7  128.98  3298.7  125.91  3558.7  122.32  3848.7  114.12  3998.7  114.45
  4078.7  117.35  4108.7  114.53  4178.7  117.62  4465.6  110.24  4905.6  110.82
  4945.6   95.18 5000.88   90.64 5014.47   92.18  5065.6  106.69  5095.6   107.7
  5125.6   111.8  5135.6  112.37  5280.9  110.21    5625     112    5660     120
    6471     120    6522   114.2  6730.9  116.61  6770.9   117.5  6790.9  120.56
  6950.9  117.82  7250.9  125.25  7360.9  122.88  7490.9  126.92  7914.1  126.63
#Mann= 7 ,-1 , 0
  2628.7     .14       0  4905.6     .06       0  5125.6     .14       0
  5135.6     .06       0    5660     .14       0    6522     .08       0
  6730.9      .1       0
Bank Sta=4905.6,5125.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,111378  ,90.7,94,89.7
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3056541.18      13925988.1      3057783.41     13924804.55
      3058272.48     13923748.17      3059035.42     13921469.11
#Sta/Elev= 30
2204.865  128.312807.634  126.013002.898  121.813164.202  114.513308.528  114.21
3384.935  117.313401.915  115.013478.322  116.913605.668  111.213913.589  111.62
3959.858   109.93981.507  106.174102.486  104.124163.103   96.234224.653   96.42
4227.879   91.064243.331   90.454262.432   92.174285.354   98.554302.164  107.06
4336.462  113.024612.378  116.814700.756  114.615651.604  115.915668.584  114.41
5812.909  119.415889.316  117.416135.518  124.416432.658  123.816690.236  126.91
#Mann= 4 ,-1 , 0
2204.865     .14       03913.589     .06       04336.462     .14       0
5651.604     .99       0
#XS Ineff= 2 , 0
       03911.807   115.54353.866       0   114.5
Permanent Ineff=
       F       F
Bank Sta=3913.589,4336.462
XS Rating Curve= 0
Skew Angle= 31.9
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,111334.5,,,
BEGIN DESCRIPTION:
CUTTEN / SCHROEDER
Structure ID: K100-00-00-S16
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,67,2.6,31.9, 151, 151, , , .95, 0, ,,,
2204.8652298.2512315.231 2349.192485.0252502.0042612.371 2646.332722.7372756.696
2807.6342833.1042867.0622875.5523002.8983087.7953104.7743164.202  3249.13274.569
3308.5283384.9353393.4253401.915 3409.643410.4043427.3843435.1093461.3433478.322
3604.9043605.6683613.3933621.8833639.6263643.2773679.4433688.8673724.8633732.164
3771.981 3776.48 3818.593823.3443863.5853868.4243908.657 3908.753908.8443913.589
3920.7213920.8143920.8913920.9673959.8583981.5073981.7624042.3794042.4644102.486
 4103.084145.8684163.1034163.6114224.5684224.6534226.6054227.8794243.3314262.432
4263.1964268.8844285.1854285.3544302.1644336.4624338.5844345.3854345.4534345.546
4345.6314357.7714358.4424358.5364358.6294362.6114389.0144389.2694432.9914434.264
4476.3734476.797  4519.54520.7744522.6424563.8174612.3784649.8184658.4784700.756
4734.7154734.8854743.3754760.3544794.1434819.612 4887.534896.1894899.1614955.448
5006.3865031.8555150.7115218.6295261.0785422.382  5490.35498.7055507.2795515.769
5541.2385600.6665651.6045660.0945668.5845761.971 5770.465812.9095846.8685855.357
5872.3375889.3165897.8065906.2965923.2755931.7655965.7245991.1935999.683 6084.58
6135.5186211.9266228.9056296.8236313.8026347.7616407.1896432.6586483.5976506.094
6690.236
   128.3   127.2   127.7   126.6   126.2   126.8   126.7   126.2     126   125.3
     126   125.1     125   124.4   121.8   118.9   117.3   114.5   114.2     115
   114.2   117.3   116.4     115   116.8  116.79  116.91  116.84  116.61  116.91
   117.1  117.14   117.5   117.3  117.48  117.51  117.87  118.07  118.82  118.97
  119.77  119.88  120.92  120.97  121.35  121.36  121.41  125.01  125.01  125.02
  125.03  125.03  125.03  125.03  125.04  125.05  125.05  125.07  125.07   125.1
   125.1   125.1   125.1   125.1  125.07  125.07  125.07  125.07  125.07  125.06
  125.06  125.06  125.06  125.06  125.05  125.04  125.04  125.04  125.04  125.04
  125.04  125.04  125.04  125.04  121.44  121.44  121.37  121.37  121.21   121.2
  120.74  120.73  120.11  119.98   119.8  119.04  118.15  117.46   117.3  116.97
   116.7   116.7     117   116.6  116.35  116.21  115.66   115.6   115.7   114.4
   115.1   114.6     115   115.6   114.6   115.2   114.1  114.35   114.6   115.2
     114   116.2   115.9   114.9   114.4   117.7   118.5   119.4   117.7   117.6
   117.9   117.4   117.7   118.6   119.4   120.2   121.4   121.4   121.1   123.5
   124.4   124.1   123.4   124.3     124   124.7   124.7   123.8   125.4  125.56
   126.9
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                          116.33  116.34  116.35  116.35  116.37  116.37   116.4
   116.4   116.4   116.4   116.4  116.37  116.37  116.37  116.37  116.37  116.36
  116.36  116.36  116.36  116.36  116.35  116.34  116.34  116.34
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
        
2204.8652298.2512315.231 2349.192485.0252502.0042612.371 2646.332722.7372756.696
2807.6342833.1042867.0622875.5523002.8983087.7953104.7743164.202  3249.13274.569
3308.5283384.9353393.4253401.915 3409.643410.4043427.3843435.1093461.3433478.322
3604.9043605.6683613.3933621.8833639.6263643.2773679.4433688.8673724.8633732.164
3771.981 3776.48 3818.593823.3443863.5853868.4243908.657 3908.753908.8443913.589
3920.7213920.8143920.8913920.9673959.8583981.5073981.7624042.3794042.4644102.486
 4103.084145.8684163.1034163.6114224.5684224.6534226.6054227.8794243.3314262.432
4263.1964268.8844285.1854285.3544302.1644336.4624338.5844345.3854345.4534345.546
4345.6314357.7714358.4424358.5364358.6294362.6114389.0144389.2694432.9914434.264
4476.3734476.797  4519.54520.7744522.6424563.8174612.3784649.8184658.4784700.756
4734.7154734.8854743.3754760.3544794.1434819.612 4887.534896.1894899.1614955.448
5006.3865031.8555150.7115218.6295261.0785422.382  5490.35498.7055507.2795515.769
5541.2385600.6665651.6045660.0945668.5845761.971 5770.465812.9095846.8685855.357
5872.3375889.3165897.8065906.2965923.2755931.7655965.7245991.1935999.683 6084.58
6135.5186211.9266228.9056296.8236313.8026347.7616407.1896432.6586483.5976506.094
6690.236
   128.3   127.2   127.7   126.6   126.2   126.8   126.7   126.2     126   125.3
     126   125.1     125   124.4   121.8   118.9   117.3   114.5   114.2     115
   114.2   117.3   116.4     115   116.8  116.79  116.91  116.84  116.61  116.91
   117.1  117.14   117.5   117.3  117.48  117.51  117.87  118.07  118.82  118.97
  119.77  119.88  120.92  120.97  121.35  121.36  121.41  125.01  125.01  125.02
  125.03  125.03  125.03  125.03  125.04  125.05  125.05  125.07  125.07   125.1
   125.1   125.1   125.1   125.1  125.07  125.07  125.07  125.07  125.07  125.06
  125.06  125.06  125.06  125.06  125.05  125.04  125.04  125.04  125.04  125.04
  125.04  125.04  125.04  125.04  121.44  121.44  121.37  121.37  121.21   121.2
  120.74  120.73  120.11  119.98   119.8  119.04  118.15  117.46   117.3  116.97
   116.7   116.7     117   116.6  116.35  116.21  115.66   115.6   115.7   114.4
   115.1   114.6     115   115.6   114.6   115.2   114.1  114.35   114.6   115.2
     114   116.2   115.9   114.9   114.4   117.7   118.5   119.4   117.7   117.6
   117.9   117.4   117.7   118.6   119.4   120.2   121.4   121.4   121.1   123.5
   124.4   124.1   123.4   124.3     124   124.7   124.7   123.8   125.4  125.56
   126.9
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                          116.33  116.34  116.35  116.35  116.37  116.37   116.4
   116.4   116.4   116.4   116.4  116.37  116.37  116.37  116.37  116.37  116.36
  116.36  116.36  116.36  116.36  116.35  116.34  116.34  116.34
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
        
Pier Skew, UpSta & Num, DnSta & Num=  ,3981.507, 2 ,3981.507, 2 , 0 , 0 , 0 ,,
       4       4
  105.12  117.35
       4       4
  104.73  116.96
Pier Skew, UpSta & Num, DnSta & Num=  ,4042.464, 2 ,4042.464, 2 , 0 , 0 , 0 ,,
       4       4
  103.69  117.37
       4       4
   103.3  116.98
Pier Skew, UpSta & Num, DnSta & Num=  ,4102.486, 2 ,4102.486, 2 , 0 , 0 , 0 ,,
       4       4
  102.94   117.4
       4       4
  102.55  117.01
Pier Skew, UpSta & Num, DnSta & Num=  ,4163.103, 2 ,4163.103, 2 , 0 , 0 , 0 ,,
       4       4
   95.22   117.4
       4       4
   94.83  117.01
Pier Skew, UpSta & Num, DnSta & Num=  ,4224.653, 2 ,4224.653, 2 , 0 , 0 , 0 ,,
       4       4
    91.9  117.37
       4       4
   91.51  116.98
Pier Skew, UpSta & Num, DnSta & Num=  ,4285.354, 2 ,4285.354, 2 , 0 , 0 , 0 ,,
       6       6
   96.98  117.36
       6       6
   96.59  116.97
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=128.31

Type RM Length L Ch R = 1 ,111284  ,217.4,206,204.3
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3056627.48     13926004.81      3057872.46     13924818.64
      3058363.59      13923757.8      3059126.89      13921477.7
#Sta/Elev= 30
2204.865   127.92807.634   125.63002.898   121.43164.202   114.13308.528   113.8
3384.935   116.93401.915   114.63478.322   116.53605.668   110.83913.589  111.21
3959.858  109.493981.507  105.764102.486  103.714163.103   95.824224.653   96.01
4227.879   90.654243.331   90.044262.432   91.764285.354   98.144302.164  106.65
4336.462  112.614612.378   116.44700.756   114.25651.604   115.55668.584     114
5812.909     1195889.316     1176135.518     1246432.658   123.46690.236   126.5
#Mann= 4 ,-1 , 0
2204.865     .14       03913.589     .06       04336.462     .14       0
5651.604     .99       0
#XS Ineff= 2 , 0
       03911.807   115.54353.866       0   114.5
Permanent Ineff=
       F       F
Bank Sta=3913.589,4336.462
XS Rating Curve= 0
Skew Angle= 31.9
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,111078. ,472.1,214,24.6
BEGIN DESCRIPTION:
K100-00-00-S16_CUTTEN/SCHROEDER -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3056835.94      13926018.2      3058080.92     13924832.03
      3058572.06     13923771.19      3059335.35     13921491.09
#Sta/Elev= 30
  2592.7  127.04  3022.7  126.53  3622.7  112.84  3912.7  117.06  3952.7   112.6
  4072.7  110.75  4092.7  104.38  4102.7  105.18  4232.7   95.96  4422.3   97.59
  4472.3  101.87  4572.3  113.32  4912.3  113.53  4932.3  110.41  5000.4    89.8
 5021.63    93.7 5058.63  106.53  5072.3  118.95  5262.3  114.64  5302.3  105.55
  5481.3  103.04  5601.3  107.44  5621.3  112.58  5671.3  114.83  6201.3  114.34
  6791.3  114.46  6981.3  119.78  7121.3  116.83  7231.3  120.17  7885.8  125.56
#Mann= 8 ,-1 , 0
  2592.7     .14       0  4102.7    .026       0  4472.3     .14       0
  4912.3     .06       0  5072.3     .12       0  5302.3    .026       0
  5601.3     .14       0  6201.3      .1       0
#XS Ineff= 2 , 0
         3910.17   117.5
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
 4042.55 4609.93  111.76 5252.96  5664.3  114.26
Bank Sta=4912.3,5072.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,110864  ,451.8,1158,632.8
BEGIN DESCRIPTION:
Cross Section XS33.7
END DESCRIPTION:
XS GIS Cut Line= 6
      3057440.92       13927127.      3058432.77     13925257.99
       3058551.1      13924414.3      3058590.94     13924175.47
      3058650.44     13923621.94       3059332.1     13921513.33
#Sta/Elev= 30
  1840.3     129  2500.3   120.5  3070.3     125  3290.3   117.6  3400.3   119.5
  3510.3   112.7  3720.3   109.7  4016.2   111.1  4036.2   110.7  4096.2    99.3
  4286.2    96.3  4516.2   109.7  4746.2     107  4888.2   112.3  4937.3   111.1
  4977.3      93    5006   89.56  5060.3   108.4  5120.3   113.7  5220.3   115.6
  5240.3   114.9  5280.3   104.3  5380.3   101.6  5560.3   104.7    5607   114.5
    6297   114.4    6777   114.8    6927   119.4    7077     117  7823.1   125.5
#Mann= 9 ,-1 , 0
  1840.3     .14       0  4016.2    .026       0  4516.2     .14       0
  4937.3     .06       0  5120.3     .14       0  5220.3    .026       0
    5607     .14       0    6297      .1       0    6927     .99       0
#XS Ineff= 2 , 0
         4035.16  122.81 6919.92          122.47
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
    4016 4516.19   109.7    5225 5607.02   114.5
Bank Sta=4937.3,5120.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,109706  ,77.2,123,339.5
BEGIN DESCRIPTION:
Cross Section XS33.6
END DESCRIPTION:
XS GIS Cut Line= 6
      3057759.28      13927271.4      3059132.37     13924671.54
      3059127.21     13924533.97      3059103.14     13924389.51
      3059019.81     13924010.09      3060257.93     13921658.56
#Sta/Elev= 30
  1829.1   128.1  2989.1   125.8  3449.1   113.2  4039.1   110.3  4179.1   114.5
  4379.1   109.9  4459.1   110.5  4669.1   104.5  4769.3   106.6  4899.3   113.6
    4947    96.3  4948.7   93.39    5006   88.29  5017.3   90.27  5053.5     109
  5063.5   109.8  5113.5   108.4  5521.9   114.7  5851.9   113.4  6031.9   116.6
  6341.9   115.1  6661.9   117.1  6951.9   114.8  7081.9   119.3  7131.9   115.9
  7271.9   115.1  7341.9   115.8  7411.9   119.9  7491.9   117.7  8099.5     126
#Mann= 5 ,-1 , 0
  1829.1     .14       0  4899.3     .06       0  5063.5     .14       0
  6031.9      .1       0  6661.9     .99       0
#XS Ineff= 2 , 0
         4523.44  121.91 5906.25          122.25
Permanent Ineff=
       F       F
Bank Sta=4899.3,5063.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,109583. ,64,155,316.4
BEGIN DESCRIPTION:
K100-00-00-S15_BNRR -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3057831.62      13927269.3       3059200.4     13924682.25
      3059289.35     13924024.98      3060632.25     13921770.55
#Sta/Elev= 30
  1821.9  126.13  3011.9  124.81  3861.9  108.63  4211.9  110.06  4351.9  105.95
  4421.9  110.05  4451.9   106.3  4521.9  104.73  4711.9  104.28  4788.8  106.17
  4838.8  111.69  4928.8  112.04  4948.8  104.49 4952.58   94.93 4957.69   92.55
    5006   88.15 5032.24   94.94  5068.8  109.89  5178.8  108.15    5412  112.87
    5552  109.44    5782  109.62    5912   112.2    5972   119.3    6002   119.5
    6122   114.5    7102  115.68    7252     117    7402  122.75  8036.1  125.99
#Mann= 3 ,-1 , 0
  1821.9     .14       0  4928.8     .06       0  5068.8     .12       0
#XS Ineff= 2 , 0
        4609.854121.86135560.589        121.9491
Permanent Ineff=
       F       F
Bank Sta=4928.8,5068.8
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,109428  ,32,28,36.4
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3057874.64     13927320.15      3059298.31      13924608.4
      3059416.26     13924383.73      3060750.36      13921842.6
#Sta/Elev= 30
    1837  126.51    3017  124.11    3587  114.21    3687  117.11    3717  113.11
    3857  110.81    4217  111.81    4297  107.41    4757  109.28  4788.2   99.54
  4813.1  103.63  4893.5   94.94  4927.6  100.31  4948.7   93.07    5006   87.97
  5030.5   88.46    5057  102.89  5423.5  100.81  5443.5  105.41  5503.5  104.01
  5543.5  108.01  5803.5  109.51  5873.5  121.41  5913.5  122.11  6033.5  114.71
  6743.5  108.31  7223.5  113.81  7333.5  121.81  7533.5  125.31  8023.5  125.61
#Mann= 4 ,-1 , 0
    1837     .14       0    4757     .06       0    5057     .14       0
  5913.5      .1       0
#XS Ineff= 2 , 0
       0 4718.75   121.8    5125       0  121.57
Permanent Ineff=
       F       F
Bank Sta=4757,5057
XS Rating Curve= 0
Exp/Cntr=.5,.3
