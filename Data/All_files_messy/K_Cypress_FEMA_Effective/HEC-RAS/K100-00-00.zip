HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,243570  ,923.5,1145,1146.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X97
ROB spills into U101-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 5
      2965297.49      13899014.1      2965603.92     13895842.41
      2966418.38      13894372.2       2966731.6     13894029.99
      2969459.77     13891067.72
#Sta/Elev= 30
   -55.6  166.72  2084.4  165.15  2564.4  165.97  3130.9  165.35    3164   164.3
    3214     166    3244   165.1    3264   166.5    3324   165.5    3584   166.3
 4847.41  165.29  4903.5  166.51  4914.6  172.32  4937.5  166.87  4965.6  165.74
  4976.3  162.61  4990.7  156.11    4999  155.32  5009.5  156.14  5011.7  157.86
  5020.6  158.17  5047.4  165.06    5145  165.32  5885.6   164.6  6695.6   165.4
  7095.6   164.4  7555.6   165.3  7595.6   161.9  7675.6     165  9302.7   165.5
#Mann= 5 ,-1 , 0
   -55.6      .2       0  4914.6      .4       0  4965.6     .06       0
  5047.4      .4       0    5145      .2       0
Bank Sta=4965.6,5047.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,242425  ,1088.2,1978,1831.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X96
ROB spills into U101-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
      2965914.48      13898919.9       2966503.7     13895899.24
      2967029.13     13895096.49      2967236.01      13894981.6
       2970206.3     13892092.03
#Sta/Elev= 30
   853.3  168.41   933.3  167.95   983.3  169.27  1623.3  166.36  2283.3  167.46
  3943.2   165.5  3983.2   163.5  4033.2   165.5  4073.2   164.4  4573.2     166
  4863.2   164.6  4890.3   166.6    4933  169.32  4941.5  164.97  4968.8  163.03
  4992.4  157.59  4997.4   154.1  5025.9  157.33  5045.9  162.42  5072.9   163.7
  5246.9   165.5  5506.9   166.4  7026.9   163.9  7376.9   164.6  7416.9     160
  7446.9   162.6  7506.9   164.5  7846.9   163.5  8386.9   165.6  9270.9   165.1
#Mann= 5 ,-1 , 0
   853.3      .2       0  4890.3     .56       0  4968.8      .1       0
  5072.9     .56       0  5246.9      .2       0
Bank Sta=4968.8,5072.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,240447  ,71.5,398,1047.2
BEGIN DESCRIPTION:
Cross Section XS95.6
LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 6
      2966951.36      13898894.2      2967550.84     13895980.36
       2967780.4     13895704.47      2968815.53     13895792.41
      2968963.25     13895513.26      2971885.35     13893445.13
#Sta/Elev= 30
   432.3  166.33  1582.3  165.44  1832.3  167.87  2262.3  165.59  3162.3  164.86
  3232.3  166.04  3292.3  164.92  3564.7   165.9  3584.7   164.7  3704.7   166.5
  4416.1   165.3  4566.1   165.7  4616.1   164.2  4796.1   163.6  4834.9   165.6
  4898.6   164.4  4938.6   166.7  4961.6  159.16  4986.8   156.1  5000.3   152.4
  5005.4  153.18  5006.8  154.23    5008  157.65  5020.7  163.67  5068.6   166.2
  5170.8   163.3  5230.8     165  5550.8   165.5  5630.8   164.4  8700.7   167.2
#Mann= 7 ,-1 , 0
   432.3      .2       0  3564.7     .48       0  4416.1     .56       0
  4938.6      .1       0  5068.6     .56       0  5230.8     .48       0
  5550.8      .2       0
Bank Sta=4938.6,5068.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,240049. ,75.7,102,105.3
BEGIN DESCRIPTION:
K100-00-00-S147_SHARP -US - XS4
ROB spills into U101-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 6
       2967079.9      13898902.7      2967664.54     13895940.85
      2967814.08     13895761.78      2969143.03       13895867.
      2970151.32     13895850.57      2972099.02     13895536.73
#Sta/Elev= 30
   304.1  166.18  1714.1  166.94  3044.1  165.03  3304.1  166.37  3453.2  164.47
  3548.2  166.34  4386.5  164.46  4636.5  162.56  4696.5  164.05  4726.5  167.21
  4776.5  163.92  4826.5  165.54  4856.5   160.7  4899.6  165.68  4919.6  163.29
 4966.44  152.07  4979.6  158.31  4999.6  163.45    5000  163.45  5029.6  165.65
  5101.6  164.04  6169.5  163.47  7089.5  166.27  7109.5  168.07  7139.5  163.89
  7159.5  163.76  7189.5  165.84  7219.5  164.68  7229.5  166.74  7892.3  165.58
#Mann= 6 ,-1 , 0
   304.1      .2       0  4386.5     .56       0  4899.6      .1       0
  4999.6      .4       0    5000     .56       0  5101.6      .2       0
Bank Sta=4899.6,4999.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,239947  ,176.9,48,50.2
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
ROB spills into U102-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 6
      2967199.87      13898911.3      2967727.87     13895967.94
      2967858.93     13895811.06      2969118.88     13895911.28
      2970154.66     13895947.31      2972102.35     13895633.47
#Sta/Elev= 30
-448.298  166.152572.103  166.262702.095  164.242886.498  165.922949.444  164.11
2966.083  166.113341.544  165.113790.799  161.51 4013.18  164.674059.687  162.85
4097.042  157.814127.824  158.754148.789  155.69 4160.02  151.994164.263  152.77
4165.428  153.824166.426  157.244176.992  163.264288.557  164.584301.369  162.61
 4476.08  161.714484.399  163.114501.039  161.714550.956  164.215205.454  163.81
5871.017  166.615895.976  164.015929.254  163.915954.212  166.11 6538.91  165.21
#Mann= 5 ,-1 , 0
-448.298      .2       03341.544     .48       04127.824     .04       0
4176.992     .48       0 4476.08      .2       0
#XS Ineff= 2 , 0
-839.9994119.504     1644185.312-839.999   163.9
Permanent Ineff=
       F       F
Bank Sta=4127.824,4176.992
XS Rating Curve= 0
Skew Angle= 33.7
Exp/Cntr=.5,.3

Type RM Length L Ch R = 2 ,239924  ,,,
BEGIN DESCRIPTION:
SHARP RD
Structure ID: K100-00-00-S147
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,26,2.6,33.7, 60, 60, , , .95, 0, ,,,
2966.0833025.401 3416.423466.3453549.532 3591.133599.4493616.0893641.0473790.799
3824.0853832.4053849.0443857.3643940.5513990.468 4013.184059.6954080.5684097.042
4098.0314098.1234127.8324148.789 4160.024164.2634165.4284166.4354176.9924202.874
4202.9584210.0214288.5654301.3694309.6894426.1634434.4824451.121 4459.44 4476.08
4484.3994492.7194501.0394526.0054550.9644850.4594867.0984883.7465005.7935205.462
5488.3185871.0255879.3455895.9845929.2545954.2125970.8525987.491 6353.55 6538.91
  166.11   165.8  165.28  165.11  164.84  164.71  164.68  164.63  164.55  164.08
  164.06  164.08  164.12  164.14  164.34  164.46  164.67  164.73  164.95  165.13
  165.14  167.44  167.56  167.64  167.59  167.56  167.55  167.55  167.47  167.28
  164.98  164.96   164.8  164.79  164.78  164.69  164.68  164.67  164.66  164.65
  164.64  164.64  164.63  164.61  164.59  164.35  164.34  164.33  164.51  164.22
   164.5   166.6   166.3     164   163.9   166.1     165   165.8   166.1   165.2
   166.1   165.4   164.8   163.9   164.3     163   163.6     163   163.4   161.5
   161.7     163   161.9   163.1   162.8   163.5  164.66  162.84  159.33   157.8
  157.83  157.83  158.74  155.68  151.98  152.76  153.81  157.23  163.25  163.82
  163.82  164.12  164.57   162.6   163.2   161.7   162.5   161.8   162.7   161.7
   163.1   162.9   161.7   162.3   164.2   163.7   164.3   163.7   164.5   163.8
   164.5   166.6   166.3     164   163.9   166.1     165   165.8   166.1   165.2
 2966.083025.3993416.4173466.343 3549.533591.1273599.4473616.0863641.0453790.797
3824.0833832.4023849.0423857.3613940.5483990.4664013.1784059.6924080.5664097.039
4098.029 4098.124127.8294148.7864160.0184164.2614165.4254166.4324176.9894202.872
4202.9554210.0184288.5634301.3674309.686 4426.164434.4794451.1184459.4384476.077
4484.3964492.7164501.0364526.0024550.9614850.4564867.0954883.7435005.791 5205.46
5488.3155871.0235879.3435895.9815929.251 5954.215970.8495987.4886353.5486538.907
  166.11   165.8  165.28  165.11  164.84  164.71  164.68  164.63  164.55  164.08
  164.06  164.08  164.12  164.14  164.34  164.46  164.67  164.73  164.95  165.13
  165.14  167.44  167.56  167.64  167.59  167.56  167.55  167.55  167.47  167.28
  164.98  164.96   164.8  164.79  164.78  164.69  164.68  164.67  164.66  164.65
  164.64  164.64  164.63  164.61  164.59  164.35  164.34  164.33  164.51  164.22
   164.5   166.6   166.3     164   163.9   166.1     165   165.8   166.1   165.2
   166.1   165.4   164.8   163.9   164.3     163   163.6     163   163.4   161.5
   161.7     163   161.9   163.1   162.8   163.5  164.66  162.84  159.33   157.8
  157.83  157.83  158.74  155.68  151.98  152.76  153.81  157.23  163.25  163.82
  163.82  164.12  164.57   162.6   163.2   161.7   162.5   161.8   162.7   161.7
   163.1   162.9   161.7   162.3   164.2   163.7   164.3   163.7   164.5   163.8
   164.5   166.6   166.3     164   163.9   166.1     165   165.8   166.1   165.2
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Culvert=1,7,,31,.014,.9,1,1,3,153.15,4141.22,152.72,4141.22,Culvert #1  , 0 ,10
Culvert Bottom n=.014
Culvert=1,7,,31,.014,.9,1,1,3,152.71,4149.2,152.27,4149.2,Culvert #2  , 0 ,10
Culvert Bottom n=.014
Culvert=1,7,,31,.014,.9,1,1,3,152.27,4157.44,151.77,4157.44,Culvert #3  , 0 ,10
Culvert Bottom n=.014
Culvert=1,7,,31,.014,.9,1,1,3,152.66,4165.59,152.57,4165.59,Culvert #4  , 0 ,10
Culvert Bottom n=.014
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=171.01

Type RM Length L Ch R = 1 ,239899  ,120.1,96,101.4
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
ROB spills into U102-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 6
      2967259.85      13898919.9      2967775.51     13895974.76
      2967873.93     13895856.95      2969123.91     13895956.37
      2970162.23     13895992.49      2972111.82     13895678.34
#Sta/Elev= 30
-393.298  166.192366.701  164.81 2832.97   166.72949.444   164.42983.803   166.4
3641.047   163.73790.799   161.8 4013.18  164.964059.687  163.144097.042   158.1
4127.824  159.044148.789  155.98 4160.02  152.284164.263  153.064165.428  154.11
4166.426  157.534176.992  163.554288.557  164.874301.369   162.9 4476.08     162
4484.399   163.44501.039     1624534.316   163.65205.454   164.15871.017   166.9
5895.976   164.35929.254   164.25954.212   166.45970.852   165.3 6538.91   165.5
#Mann= 5 ,-1 , 0
-393.298      .2       03641.047     .48       04127.824     .04       0
4176.992     .48       04534.316      .2       0
#XS Ineff= 2 , 0
-839.9994119.504     1644185.312-839.999   163.9
Permanent Ineff=
       F       F
Bank Sta=4127.824,4176.992
XS Rating Curve= 0
Skew Angle= 33.7
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,239803. ,1402.7,811,583.6
BEGIN DESCRIPTION:
K100-00-00-S147_SHARP -DS - XS1
ROB spills into U102-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 6
      2967345.55      13898954.2      2967881.94     13895949.35
      2969131.91     13896048.78      2969391.88     13896060.93
      2970170.24      13896084.9      2972119.83     13895770.75
#Sta/Elev= 30
   524.6  165.68  1064.6  166.58  1214.6  165.06  3364.6  164.65  3544.6  166.39
    3697  164.96    3917  165.89    4417  164.95    4577   162.5    4607  161.44
    4677  165.35    4747     163  4950.9  164.77  4960.9  163.47 4974.24  158.09
 4988.31  155.91 4999.96  152.19  5030.9  161.91  5040.9  163.51  5111.2  165.42
  5181.2  163.91  6149.9  164.51  6259.9  161.83  6359.9  164.23  6529.9  162.94
  6649.9  164.89  7019.9   165.8  7079.9  163.61  7169.9  166.29  7844.6  165.08
#Mann= 5 ,-1 , 0
   524.6      .2       0    4577     .56       0  4950.9     .04       0
  5040.9     .56       0  5181.2     .24       0
Bank Sta=4950.9,5040.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,238992  ,937.5,1770,1296.9
BEGIN DESCRIPTION:
Cross Section XS95.2
ROB spills into U102-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 4
      2967628.33       13898997.       2969442.3     13896898.31
      2969588.86     13896757.85      2972192.17     13896109.79
#Sta/Elev= 30
  2132.7  165.81  2492.7  166.13  2632.7  164.74  2852.7  164.83  2872.7  165.67
  2952.7  164.66  4854.8   162.8  4936.8   163.1  4956.8   164.1  4966.8   160.8
  4976.8   155.9  4986.8  155.17  5000.3  151.47  5005.4  152.25  5006.8   153.3
    5008  156.72  5020.7  162.74  5056.8   163.3  5086.8   166.3  5189.8   163.2
  6119.8   162.8  6559.8   163.7  6589.8     166  6619.8   166.8  7089.8   164.3
  7129.8   165.4  7559.8   165.5  7659.8   166.9  7719.8   164.8  7792.5   166.5
#Mann= 6 ,-1 , 0
  2132.7      .2       0  4854.8     .56       0  4956.8     .04       0
  5020.7      .4       0  5056.8     .56       0  5189.8      .2       0
Bank Sta=4956.8,5020.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,237222  ,845.6,970,774
BEGIN DESCRIPTION:
Cross Section K100-00-00-X95B
ROB spills into U102-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 5
      2968459.55      13899211.2      2970742.96     13897523.31
      2970942.85      13897515.5      2971517.06     13897480.48
      2972577.57     13896992.94
#Sta/Elev= 30
  2036.4  164.92  2796.4   164.5  3186.4   165.4  3216.4   164.7  3266.4  165.64
  3286.4   164.8  3326.4  165.41  3346.4  164.79  4452.9     163  4842.9   163.1
  4890.9  161.47    4952  161.86  4995.6  151.11    4997  149.88  5003.3  149.94
  5004.3  151.18  5024.2   159.5  5024.8  163.69    5026   161.9    5046     165
    5066   166.5  5086.1   164.3  5109.9  163.27  5386.1   162.2  5556.1   164.5
  6051.4   164.3  6141.4   165.4  6251.4   163.8  6781.4   163.6  6818.6   164.9
#Mann= 5 ,-1 , 0
  2036.4      .2       0  4890.9     .56       0    4952     .04       0
  5024.8     .56       0  5109.9      .2       0
Bank Sta=4952,5024.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,236252  ,1652.3,1366,985.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X95B-1-INTERP
ROB spills into U102-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 4
      2969145.09      13899468.3      2970445.01     13898524.86
      2971499.56     13898351.17      2972864.27     13897681.22
#Sta/Elev= 30
  2805.9  165.47  3135.9  164.15  3245.9  164.89  3335.9  164.16  4105.9   164.8
  4125.9  164.12  4205.9  164.88  4375.9  163.61  4405.9  164.37  4642.1  163.77
  4682.1  164.66    4890  164.44    4920  163.14    4940  163.34  4956.1   162.1
  4972.6   158.5  4990.8     152    5000   149.7  5022.2   155.7  5032.4     160
  5033.2     163  5262.2  163.15  5302.2  164.47  5352.2   163.4  5610.9  165.38
  5910.9  164.81  6290.9   165.5  6460.9  164.28  6900.9  163.35  7001.2  164.05
#Mann= 5 ,-1 , 0
  2805.9      .2       0  4405.9     .56       0  4956.1     .04       0
  5033.2     .56       0  5262.2      .2       0
Bank Sta=4956.1,5033.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,234886  ,912.9,754,803.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X95A-1-INTERP
ROB spills into U102-00-00
END DESCRIPTION:
XS GIS Cut Line= 4
      2970048.79     13902287.52      2970655.92     13900050.86
      2971400.31     13899517.38      2972988.34     13898574.49
#Sta/Elev= 30
  2165.5  176.95  2445.5  176.01  3135.5  169.47  3185.5  170.44  3375.5  169.82
  3385.5  169.39  3415.5  160.45  3425.5  162.58  3435.5  166.84  3455.5  169.32
  3495.5  165.33  4813.1   163.4  4873.1  164.41  4961.8   162.4  4976.8   159.9
  4993.2   151.1    5000   149.5    5009     153  5021.4     153  5030.8   154.7
    5045     162  5123.1  164.55  5253.1   162.8  5383.1   163.9  5468.9  161.61
  5578.9  165.07  5838.9  164.87  6638.9  164.58  6658.9  163.57  7245.8  164.68
#Mann= 5 ,-1 , 0
  2165.5      .2       0  4813.1     .56       0  4961.8     .04       0
    5045     .56       0  5838.9      .2       0
Bank Sta=4961.8,5045
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,234132  ,351.3,540,703.8
BEGIN DESCRIPTION:
Cross Section k100-00-00-X95a
ROB spills into U102-00-00
END DESCRIPTION:
XS GIS Cut Line= 4
      2970082.67     13902282.42      2971498.98     13900431.58
      2971713.38     13900131.82      2973181.63     13899469.92
#Sta/Elev= 30
  2460.1   176.9  2720.1   175.8  3430.7  168.06  3520.1   166.5  3550.1   162.6
  3560.1     163  3580.1   166.1  3605.7  165.95  3640.1   164.4  3880.1   165.2
  4490.1   163.9  4610.1   164.9  4874.3  163.37    4965  162.54  4979.1  160.62
  4994.6  150.58  5000.9  149.32    5005   150.4  5011.1  153.98    5025  152.79
  5035.5  154.17  5051.4  161.45  5100.7   164.8  5120.7   163.4  5299.2   162.3
  5379.2   164.7  5427.9   164.6  6139.2   165.2  6179.2   163.3  6769.8   164.1
#Mann= 7 ,-1 , 0
  2460.1      .2       0  3430.7      .4       0  3605.7     .24       0
  4874.3     .56       0    4965     .04       0  5051.4     .56       0
  5427.9      .2       0
Bank Sta=4965,5051.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,233592  ,1164.3,1474,1279.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X95
ROB spills into U102-00-00
END DESCRIPTION:
XS GIS Cut Line= 4
      2970209.97     13902360.45      2971879.35     13900590.49
      2972182.14     13900552.52      2973265.21     13900349.09
#Sta/Elev= 30
  2415.9   177.2  3145.9   170.9  3339.7  167.41  3395.9   166.8  3415.9  163.48
  3448.1  165.63  3473.2  159.94  3479.8  156.51  3484.5  160.83  3488.7  160.95
  3495.2  165.38  3511.2  166.29  3564.2  164.61  4615.9   164.1  4703.6  162.59
  4908.9     162  4926.6     160  4956.4  160.11  4964.4  157.03  4990.3  154.08
  4992.2  151.36  5001.3  148.74  5010.5  154.53    5021  158.39  5026.4  162.66
  5054.3   168.4  5063.2  168.16  5073.1  163.82  5124.2  163.14  6256.1   163.8
#Mann= 7 ,-1 , 0
  2415.9      .2       0  3339.7      .4       0  3511.2     .24       0
  4703.6     .56       0  4956.4     .04       0  5026.4     .56       0
  5124.2      .2       0
Bank Sta=4956.4,5026.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,232118  ,1083.6,1205,628.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X94
ROB spills into U102-00-00
END DESCRIPTION:
XS GIS Cut Line= 4
      2970642.79     13902665.98      2972238.25     13901916.74
      2972495.83     13901780.02      2974385.46     13901189.28
#Sta/Elev= 30
  3061.1   175.7  3171.1   177.3  3471.1   174.7  4080.2  164.16  4100.2  163.15
  4115.1  158.62  4119.3  154.56  4123.6  154.51    4126  154.95 4126.11  157.97
  4143.4  159.42  4155.9  163.78  4253.2  161.74  4391.1   164.1  4544.1  163.54
    4974  161.38  4989.1  153.66  4992.1  149.42  5000.1  148.53  5007.8  149.63
  5013.6  153.46  5037.3  154.89  5047.7  160.26  5083.7   164.1  5113.7   164.7
  5145.3   162.8  5271.8  163.05  5555.3     165  6815.3     165  7095.2   163.3
#Mann= 5 ,-1 , 0
  3061.1      .2       0  4544.1     .56       0    4974     .04       0
  5047.7     .56       0  5271.8      .2       0
Bank Sta=4974,5047.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,230913  ,1492.9,1570,1049.2
BEGIN DESCRIPTION:
Cross Section XS93.5
ROB spills into U102-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
      2971106.81      13903265.6      2972026.89     13903309.46
      2972392.85     13903009.35      2972523.19      13902911.6
      2974470.59     13901320.38
#Sta/Elev= 30
  3504.7   174.5  4194.7   173.4  4284.7   173.8  4314.7   173.8  4364.7   172.4
  4655.8   168.1  4735.8     166  4775.8   163.1  4899.1   160.9    4974  160.65
  4982.3  156.99  4989.1  152.93  4991.3   149.3  4992.1  148.69  5000.1   147.8
  5007.8   148.9  5013.6  152.73  5037.3  154.16  5039.1   158.6    5072     161
    5112   161.4    5142   162.7    5582   162.9    6552   163.5    6622   163.1
    6672   161.7    6772   163.9    7032   163.1    7182   161.7  7576.8   162.9
#Mann= 5 ,-1 , 0
  3504.7      .2       0  4284.7     .48       0    4974     .04       0
    5072     .48       0    5582      .2       0
Bank Sta=4974,5072
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,229343  ,698.7,752,830.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X93-INTERP
ROB spills into U102-00-00
END DESCRIPTION:
XS GIS Cut Line= 4
      2971102.56     13903388.19      2972975.93     13903487.45
      2974092.51     13902978.78       2975792.2     13901266.69
#Sta/Elev= 30
  2313.2  173.81  2373.2  174.11  2543.2  172.98  2643.2  171.02  3053.2   173.8
  3433.2   168.8  3553.2  164.68  3703.2  162.73  3953.2  164.81  4063.2  163.22
  4289.2  163.07  4339.2  164.31  4419.2  162.86  4489.2  164.13  4709.2  162.94
  4919.2  163.13 4962.97  159.58 4985.67  152.88 4994.01  147.18    5000  146.85
 5007.18  149.05 5010.94  151.69 5017.76  154.42 5026.28   155.6 5027.44  157.16
 5048.74  160.25  5049.2  162.08  5099.2  163.64  5149.2  162.58  7828.7  162.99
#Mann= 7 ,-1 , 0
  2313.2      .2       0  3053.2     .48       0  4489.2     .99       0
 4962.97     .04       0 5048.74    .048       0  5049.2     .48       0
  5149.2      .2       0
Bank Sta=4962.97,5049.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,228591  ,1886.7,1895,1740.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X92
ROB spills into U102-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
      2971175.45     13903621.14      2972581.42     13904068.49
        2974101.     13903777.79      2974286.79     13903647.25
 2977219.185386813901611.1380208
#Sta/Elev= 30
  1888.8     172  2278.8   167.1  2498.9  166.25  3118.8   164.8  3148.8   165.1
  3188.8   167.2  3384.2   170.5  3504.2   170.1  3584.2   165.1  3964.2   166.5
  4444.2   162.9  4504.2   158.8  4554.2   154.1  4614.2   158.8  4654.2     160
  4714.2     160  4734.2   159.2  4784.2   154.5  4804.2   154.3  4884.2   161.3
  4931.4     161  4951.4   157.4 4957.69  159.06  4985.4  152.53  4993.7  146.59
  5003.2   146.4  5014.7  154.92  5037.6  159.89  5157.7  162.43  8708.4   162.3
#Mann= 6 ,-1 , 0
  1888.8      .2       0  2498.9     .48       0  4884.2     .99       0
 4957.69     .04       0  5037.6     .99       0  5157.7      .2       0
Bank Sta=4957.69,5037.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,226696  ,746.1,737,653.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X91
END DESCRIPTION:
XS GIS Cut Line= 4
      2973891.54     13905698.15      2975457.88      13905061.3
      2975755.59     13904742.89      2978460.95     13902694.47
#Sta/Elev= 30
  3199.2   166.4  3309.2   165.3  3329.2   164.4  3359.2   165.1  3459.2   164.9
  3479.2   164.4  4759.2   160.4  4849.2   160.3  4890.1     161  4954.2  161.79
    4976  154.87  4991.8  146.61  4995.9  145.74    5003  145.57  5008.3  146.62
  5014.7  152.54  5037.3  157.93  5081.5  158.11  5096.1  152.52  5099.4  152.45
  5108.5  156.69  5165.5  159.66  5224.7  160.38  5301.9  160.56    5326   161.2
    6356   162.3    7446   161.2    8196   161.4    8466   166.1  8719.3     166
#Mann= 5 ,-1 , 0
  3199.2     .48       0  4890.1     .99       0  4954.2     .04       0
  5165.5     .99       0  5224.7      .2       0
Bank Sta=4954.2,5165.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,225959  ,2114.7,1955,1423.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X90
END DESCRIPTION:
XS GIS Cut Line= 4
      2973827.63     13906401.13      2976078.33     13905506.64
      2976247.35     13905162.85      2978716.59     13903365.51
#Sta/Elev= 30
  2460.5     166  2570.5   164.9  2610.5   163.1  2680.5   162.4  3310.5   163.4
  3630.5   163.3  4080.5   161.7  4140.5   160.9  4160.5     160  4210.5   161.8
  4370.5   159.6  4840.5   159.9  4932.4     161  4932.9  160.53  4957.2   160.1
 4980.31  154.07  4995.6  146.66  5003.6   146.7  5036.6  159.34  5092.9  158.47
  5122.4   159.5  5193.7  159.57  5265.5   159.8  5585.5   160.9  5635.5   161.6
  5655.5   160.9  5895.5   161.8  5915.5     161  7835.5   161.1  8319.6   166.4
#Mann= 6 ,-1 , 0
  2460.5     .48       0  4840.5     .99       0  4957.2     .04       0
  5036.6      .4       0  5193.7     .99       0  5265.5      .2       0
Bank Sta=4957.2,5036.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,224004  ,1682.8,1666,976.2
BEGIN DESCRIPTION:
Cross Section Xs89.3
END DESCRIPTION:
XS GIS Cut Line= 5
      2973911.07      13909656.8      2977609.69     13906858.88
      2977825.54     13906199.03      2977864.26     13906097.12
      2978834.63     13903416.86
#Sta/Elev= 30
  -401.9   163.1  -251.9   160.6   -11.9     162    98.1     160   508.1   161.9
   588.1   155.3   608.1   149.7   658.1   146.6   778.1   148.5   988.1   148.5
  1118.1     162  2038.1   159.9  3378.1   160.4  3428.1   159.2  4235.8   157.7
  4495.8   157.5  4585.8   155.5  4745.8     157  4865.8   159.9    4930   157.7
 4980.31  153.61  4995.6   146.2  5003.6  146.24  5019.5  152.43  5079.1   157.5
  5219.1   156.9  5329.1   159.6  5559.1   160.6  7379.1   160.4  7889.6   166.3
#Mann= 7 ,-1 , 0
  -401.9      .2       0   508.1      .1       0  1118.1     .24       0
  4235.8     .99       0  4865.8    .048       0  5079.1     .99       0
  5559.1      .2       0
#XS Ineff= 2 , 0
         1512.11  161.27
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
   508.1    1118   161.9
Bank Sta=4865.8,5079.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,222338  ,277.8,265,277.9
BEGIN DESCRIPTION:
Cross Section XS89.1
END DESCRIPTION:
XS GIS Cut Line= 6
      2978802.76     13912152.21      2978843.18     13910060.31
      2978716.39     13908005.03      2978753.16     13906753.71
      2978753.16     13906622.78      2978928.71     13903409.55
#Sta/Elev= 30
  -483.3  165.01   646.7  160.31   766.7     161   816.7  159.21  1006.7  158.52
    2145  158.22  2157.5  154.56  2165.2  153.99  2173.6  159.21  2202.2  158.16
    2229  159.76    2579  159.72    2629  157.96  3668.2  156.97    4374     157
    4394   158.1    4434   156.6    4824     157    4874   159.6  4925.8   157.8
  4961.4  151.04  4976.1   151.1  4999.8  145.81  5031.5  154.29  5066.8   157.7
  5116.8   156.7  5336.8     158  6146.8   160.5  7746.8   160.4  8274.8   166.8
#Mann= 7 ,-1 , 0
  -483.3      .2       0    2145     .28       0  2173.6     .24       0
    4434     .99       0  4925.8    .048       0  5066.8     .99       0
  5336.8      .2       0
Bank Sta=4925.8,5066.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,222073. ,66.2,100,66.3
BEGIN DESCRIPTION:
K100-00-00-SKH_KATY-HOCKLEY -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 5
       2978815.7      13912156.8      2978923.84     13908145.81
       2978984.9     13906839.16      2979036.02     13906696.04
       2979139.1     13903455.36
#Sta/Elev= 30
  -397.3  164.88   762.7  160.16   872.7  161.01  1142.7  158.47  1352.7  159.61
  1382.7  158.59  2202.7  158.42  2262.7  159.61  2282.7   157.4  2342.7  161.24
  2402.7  159.14  2532.7  158.34  4475.2  157.58  4835.2  156.11  4924.9   158.9
 4960.44  151.16 4975.51  151.03  4999.8  145.74 5032.29  154.35 5060.38  158.68
  5063.2  160.41  5145.2  156.98  5355.2  158.11  5415.2  156.42  5565.2  157.87
  5735.2  159.31  6345.2  160.27  6415.2  159.34  7695.2     160  8317.5  166.06
#Mann= 5 ,-1 , 0
  -397.3      .2       0  4475.2     .99       0  4924.9    .048       0
  5063.2     .99       0  5565.2      .2       0
Bank Sta=4924.9,5063.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,221973  ,58.7,62,58.8
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
      2978826.34     13912165.69      2979009.03     13908164.55
       2979087.2     13906918.26      2979102.79      13906585.6
      2979224.29      13903474.1
#Sta/Elev= 30
    -373  164.44     727  160.73    1477  159.47    1617  161.06    1757  160.36
    1807  157.99    1897  160.77    2287  160.47    2357  156.75    2407  160.98
    2457  161.33  4482.3  157.97  4692.3  155.15  4812.3  159.87    4901  160.56
    4932  158.33  4961.4  150.95  4976.1  151.01  4999.8  145.72  5047.7  155.96
    5051  158.31    5081  160.47    5141  159.85    5191  154.94  5334.1  156.16
  5364.1   158.5  5464.1  156.96  5924.1  159.36  7794.1  160.37  8327.9  166.02
#Mann= 5 ,-1 , 0
    -373      .2       0  4482.3     .99       0    4932    .048       0
    5051     .99       0  5464.1      .2       0
#XS Ineff= 2 ,-1
    -374    4914   159.8    5071  8328.3  160.15
Permanent Ineff=
       T       T
Bank Sta=4932,5051
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,221943.5,,,
BEGIN DESCRIPTION:
KATY-HOCKLEY CUTOFF
Structure ID: K100-00-00-SKH
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,39,2.6,0, 133, 134, , , .95, 0, 0,0,,
    -374    -354    -334    -324    -314    -304    -294    -164    -154      -4
       6     156     166     186     196     216     226     236     246     256
   408.7   488.7   732.7   898.7   938.7   968.7   978.7   988.7  1138.7  1398.7
  1448.7  1508.7  1628.7  1852.7  2123.7    2162  2191.8  2241.7  2242.4  2292.3
  2292.9  2351.4  2357.9  2370.4  2373.3  2375.4  2378.1  2379.6  2386.5  2414.8
  2415.1    2472  2476.3    2540  2540.4  2604.4  2659.7  2999.7  3039.7  3053.7
  4752.7  4762.7    4767  4772.7  4782.7  4792.7  4812.7    4818  4832.7    4870
  4901.4  4911.4 4918.69  4918.8 4918.91  4923.7 4923.81  4923.9    4924  4931.4
    4932  4961.4  4976.1  4980.4  4989.7  4994.5    4995  4999.8  5005.2  5005.5
  5011.4  5025.7  5031.5  5058.6 5058.69  5058.8  5058.9  5061.2 5065.89    5066
 5066.11  5071.4  5111.4  5141.4  5151.4  5162.5  5171.4  5191.4  5216.8  5234.4
  7288.6  7318.6  7338.6  7388.6  7454.4  7468.6  7498.6  7568.6  7678.6  7794.4
  7838.6  7844.4  7858.6  7878.6  7928.6  7948.6  7968.6  7988.6  8008.6  8028.6
  8030.7  8054.4  8328.3
  164.44  164.37   164.9  164.92  164.44  164.43  164.63  163.88  163.59  163.34
  163.52  162.64   162.8  162.57  162.76  162.74  162.98  162.74  162.72  163.01
   162.5   162.2   161.6  161.21  161.12  161.05  161.03  161.01  160.66  160.05
  159.94   159.8  159.52     159  159.84  159.96  159.73  160.04  160.04  160.21
  160.21  160.43  160.44  160.45  160.45  160.46  160.46  160.46  160.47   160.5
   160.5  160.32  160.31  160.21  160.21  160.15  160.09  159.75  159.71   159.7
   160.1  160.31   160.4  160.48  160.63  160.78  161.08  161.16  161.22  161.36
  161.88  162.05  162.17  165.97  165.97  166.05  166.05  166.05  166.05  166.05
  166.05  166.03  166.02  166.02  166.02  166.02  166.02  166.02  166.01  166.01
  166.01  166.01  166.01     166     166     166     166  165.96  165.89  165.89
  162.09  162.01  161.42  161.15  161.06  160.96  160.88   160.7  160.48  160.15
  160.15  160.18   160.2  160.25  160.31  160.31  160.32  160.34  160.38  160.41
  161.56  161.71  161.89  162.15  162.79  163.05  163.31  163.56  163.82  164.08
  164.11   164.4   166.1
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                          160.25  160.25  160.25
  160.25  160.23  160.22  160.22  160.22  160.22  160.22  160.22  160.21  160.21
  160.21  160.21  160.21   160.2   160.2
                                                                                
                                                                                
                                                                                
                        
    -374    -354    -334    -324    -314    -304    -294    -164    -154      -4
       6     156     166     186     196     216     226     236     246     256
   408.7   488.7   732.7   898.7   938.7   968.7   978.7   988.7  1138.7  1398.7
  1448.7  1508.7  1628.7  1852.7  2123.7    2162  2191.8  2241.7  2242.4  2292.3
  2292.9  2351.4  2357.9  2370.4  2373.3  2375.4  2378.1  2379.6  2386.5  2414.8
  2415.1    2472  2476.3    2540  2540.4  2604.4  2659.7  2999.7  3039.7  3053.7
  4752.7  4762.7    4767  4772.7  4782.7  4792.7  4812.7    4818  4832.7    4870
  4901.4  4911.4 4918.69  4918.8 4918.91  4923.7 4923.81  4923.9    4924  4931.4
    4932  4961.4  4976.1  4980.4  4989.7  4994.5    4995  4999.8  5005.2  5005.5
  5011.4  5025.7  5031.5  5058.6 5058.69  5058.8  5058.9  5061.2 5065.89    5066
 5066.11  5071.4  5111.4  5141.4  5151.4  5162.5  5171.4  5191.4  5216.8  5234.4
  7288.6  7318.6  7338.6  7388.6  7454.4  7468.6  7498.6  7568.6  7678.6  7794.4
  7838.6  7844.4  7858.6  7878.6  7928.6  7948.6  7968.6  7988.6  8008.6  8028.6
  8030.7  8054.4  8328.3  8334.9
  164.44  164.37   164.9  164.92  164.44  164.43  164.63  163.88  163.59  163.34
  163.52  162.64   162.8  162.57  162.76  162.74  162.98  162.74  162.72  163.01
   162.5   162.2   161.6  161.21  161.12  161.05  161.03  161.01  160.66  160.05
  159.94   159.8  159.52     159  159.84  159.96  159.73  160.04  160.04  160.21
  160.21  160.43  160.44  160.45  160.45  160.46  160.46  160.46  160.47   160.5
   160.5  160.32  160.31  160.21  160.21  160.15  160.09  159.75  159.71   159.7
   160.1  160.31   160.4  160.48  160.63  160.78  161.08  161.16  161.22  161.36
  161.88  162.05  162.17  165.97  165.97  166.05  166.05  166.05  166.05  166.05
  166.05  166.03  166.02  166.02  166.02  166.02  166.02  166.02  166.01  166.01
  166.01  166.01  166.01     166     166     166     166  165.96  165.89  165.89
  162.09  162.01  161.42  161.15  161.06  160.96  160.88   160.7  160.48  160.15
  160.15  160.18   160.2  160.25  160.31  160.31  160.32  160.34  160.38  160.41
  161.56  161.71  161.89  162.15  162.79  163.05  163.31  163.56  163.82  164.08
  164.11   164.4   166.1   166.2
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                          160.25  160.25  160.25
  160.25  160.23  160.22  160.22  160.22  160.22  160.22  160.22  160.21  160.21
  160.21  160.21  160.21   160.2   160.2
                                                                                
                                                                                
                                                                                
                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4969.7, 2 ,4969.7, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  149.98  161.22
     1.5     1.5
  149.98  161.22
Pier Skew, UpSta & Num, DnSta & Num=  ,5014.5, 2 ,5014.5, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  148.43  161.21
     1.5     1.5
  148.43  161.21
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=167.5

Type RM Length L Ch R = 1 ,221911  ,86.6,100,86.7
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
      2978940.87     13912165.69      2979066.45     13908189.42
      2979145.18     13906934.11      2979160.78     13906601.22
      2979282.28     13903489.65
#Sta/Elev= 30
  -348.3  164.44  -208.3   162.8   421.7   161.7   451.7   160.6   541.7  161.46
   661.7  159.43  1141.7  158.49  2501.7  160.14  3591.7  159.59  3779.9  157.59
  3949.9  158.26  4089.9  156.92  4129.9  159.35  4429.9  159.47  4927.7  160.17
 4961.63  151.35 4976.23  150.87 4999.76  145.54 5033.56  154.63  5087.7  159.31
    5311  157.72    5351  158.44    5411  156.07    5531  155.92    6251  158.63
    6711  158.01    7451  160.04    7761  159.68    8151  164.34  8334.9     164
#Mann= 5 ,-1 , 0
  -348.3      .2       0  4429.9     .99       0  4927.7    .048       0
  5087.7     .99       0    5531      .2       0
#XS Ineff= 9 ,-1
     602    1038  161.54    1145    1747  160.11    1823    2285  159.88
    3847    4237  159.16    5051    5170  161.57    5743    5939  157.72
    5939    6778  160.79    6978    8124  161.81  8124.6  9484.6   163.2
Permanent Ineff=
       T       T       T       T       T       T       T       T       T
Bank Sta=4927.7,5087.7
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,221811. ,746.7,743,746.8
BEGIN DESCRIPTION:
K100-00-00-SKH_KATY-HOCKLEY -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 5
      2979027.42       13912161.        2979153.     13908184.75
      2979231.73     13906929.44      2979247.33     13906596.54
      2979368.83     13903484.97
#Sta/Elev= 30
  -312.7  164.04   697.3  161.01  1117.3  156.98  1217.3   158.7  1377.3  156.44
  1487.3  159.41  1817.3  156.78  1997.3  159.52  2117.3   157.7  2297.3  159.42
  2327.3  156.76  2507.3  159.31  2707.3  156.15  2877.3  159.81  2997.3  156.89
  3167.3  159.38  3675.5   156.2  3755.5  158.63  3815.5  156.81  3965.5  158.89
  4235.5  158.42  4475.5  155.57 4932.44  158.18 4999.76  145.54 5030.53  154.06
  5063.3   159.3  5153.3  155.95  5193.3  157.39  7816.6  160.45  8370.5   165.6
#Mann= 0 , 0 ,-1
#XS Ineff= 9 ,-1
     602    1038  161.54    1145    1747  160.11    1823    2285  159.88
    3847    4237  159.16    5051    5170  161.57    5743    5939  157.72
    5939    6778  160.79    6978    8124  161.81  8124.6  9484.6   163.2
Permanent Ineff=
       T       T       T       T       T       T       T       T       T
Bank Sta=4932.44,5063.3
XS Rating Curve= 0
Vertical n Elevations= 2
  145.54  161.38
Vertical n for Station=-312.7
      .2      .2
Vertical n for Station=4625.5
     .99     .99
Vertical n for Station=4932.44
     .04     .07
Vertical n for Station=5063.3
     .99     .99
Vertical n for Station=5163.3
      .2      .2
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,221068  ,955.9,1121,1371.6
BEGIN DESCRIPTION:
Cross Section XS89
END DESCRIPTION:
XS GIS Cut Line= 6
      2979145.57     13912041.31      2979388.68      13909106.5
      2979909.45     13907322.85      2979925.44     13907248.09
       2979971.6     13907023.91      2980181.91     13902458.82
#Sta/Elev= 30
   -53.8  164.01  1416.2  157.07  4845.7   156.5  4875.7   154.2  4885.7   155.3
  4905.7   160.5  4935.7   157.2  4971.9  153.99  4974.8  150.76  4999.5  144.38
  5018.4  148.55  5021.3  152.55  5025.7   153.8  5035.7   156.5  5045.7   157.3
  5334.6   156.2  5514.6   157.1  5614.6     156  6774.6   158.6  8064.6   159.6
  8104.6   160.7  8124.6   163.2  8154.6   162.7  8184.6     160  9374.6   159.6
  9414.6   159.8  9484.6   163.3  9524.6   161.5  9624.5   161.6  9624.5  164.51
#Mann= 0 ,-1 , 0
#XS Ineff= 3 ,-1
       0 4700.02   159.2 5051.14    6978  161.55    6978    8124  161.81
Permanent Ineff=
       T       T       T
#Block Obstruct= 1 ,-1
  8124.6  9484.6   163.2
Bank Sta=4935.7,5045.7
XS Rating Curve= 0
Vertical n Elevations= 2
  144.38  160.99
Vertical n for Station=-53.8
      .2      .2
Vertical n for Station=3871.1
     .24     .24
Vertical n for Station=4739.8
     .99     .99
Vertical n for Station=4935.7
     .04     .07
Vertical n for Station=5045.7
     .99     .99
Vertical n for Station=5614.6
      .2      .2
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,219947  ,853.2,866,725.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X88
END DESCRIPTION:
XS GIS Cut Line= 4
      2978908.31     13912823.88      2980859.17     13907664.22
      2981046.29      13907487.5 2982493.437290813902712.0112835
#Sta/Elev= 30
  -637.8   166.3    32.2     165  1752.2   156.6  3602.2     157  4142.2   155.2
  4192.2   153.6  4602.2   154.1  4732.2   155.6  4888.4   153.3  4898.4   153.4
  4925.4  160.54  4939.4  155.66  4955.2  155.17  4960.7  152.88  4971.9  152.27
  4974.8  149.04  4983.8  145.99  4999.3  144.67  4999.5  142.66  5018.4  146.83
  5021.3  150.83  5046.9  155.03  5061.4  159.78  5118.4   156.7  5188.5  157.18
  8655.7   158.9  8735.7     163  8795.7     160 10055.7   159.8 10125.7   163.7
#Mann= 7 ,-1 , 0
  -637.8     .06       0  4888.4     .14       0  4955.2     .12       0
  4971.9     .04       0  5021.3     .12       0  5046.9     .14       0
  5188.5     .06       0
#XS Ineff= 2 , 0
            4500   159.2  5061.4          159.78
Permanent Ineff=
       T       T
#Block Obstruct= 1 ,-1
  8735.7 10125.7     163
Bank Sta=4955.2,5046.9
XS Rating Curve= 0
Vertical n Elevations= 2
  142.66  160.48
Vertical n for Station=-637.8
     .24     .24
Vertical n for Station=4888.4
     .99     .99
Vertical n for Station=4955.2
     .04     .07
Vertical n for Station=5046.9
     .99     .99
Vertical n for Station=5188.5
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,219081  ,1127.8,1293,1333
BEGIN DESCRIPTION:
Cross Section XS87
END DESCRIPTION:
XS GIS Cut Line= 4
      2979556.95      13913506.2      2981531.47       13908254.
      2981620.75     13908042.98 2983196.086908813902742.0238653
#Sta/Elev= 30
  -727.8   168.7  -327.8   166.5   552.2   164.9  2232.2   155.8  3212.2   156.4
  3672.2   155.1  4312.2   156.2  4382.2   153.9  4852.2   155.4  4893.3     154
  4943.3     157  4973.3   154.7  4979.3  145.92  4998.9  143.12  5020.8  145.97
  5023.3   154.7  5053.3   157.6  5083.3   162.2  5122.5   157.4  6812.5   157.4
  9012.5   159.5  9172.5   158.6  9232.5   161.4  9252.5     165  9312.5   159.8
 10522.5   159.8 10562.5     160 10622.5   163.8 10642.5   163.9 10642.5   165.2
#Mann= 5 ,-1 , 0
  -727.8     .06       0  4382.2     .14       0  4973.3     .04       0
  5023.3     .14       0  5122.5     .06       0
#XS Ineff= 2 , 0
         4600.01   159.2 5082.75          162.17
Permanent Ineff=
       T       T
#Block Obstruct= 1 ,-1
  9252.5 10642.5     165
Bank Sta=4973.3,5023.3
XS Rating Curve= 0
Vertical n Elevations= 2
  143.12  160.24
Vertical n for Station=-727.8
     .24     .24
Vertical n for Station=4382.2
     .99     .99
Vertical n for Station=4973.3
     .04     .07
Vertical n for Station=5023.3
     .99     .99
Vertical n for Station=5122.5
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,217788  ,1677.4,1616,1588
BEGIN DESCRIPTION:
Cross Section K100-00-00-X86
END DESCRIPTION:
XS GIS Cut Line= 4
  2980541.34496213913033.7376243      2982583.02      13908925.5
      2982806.69       13908574. 2983989.253576113902742.7408687
#Sta/Elev= 30
   178.3   166.2   948.3   164.5  1188.3   162.2  2098.3   160.9  2528.3   158.5
  2588.3     157  2888.3   157.5  2998.3     156  4795.9   156.5    4926  153.28
  4965.9  151.07  4982.1   145.4  4998.9   143.8  5017.7  145.44  5033.5  154.34
  5046.4  155.41  5063.5  160.83  5074.7  160.62  5085.9   157.5  5145.9   156.8
  6482.5   157.3  6592.5   156.2  8322.5   158.7 10182.5   158.6 11072.5   160.5
 11102.5   160.2 11112.5   158.2 11122.5   158.4 11132.5   160.8 11132.5  162.71
#Mann= 0 ,-1 , 0
#XS Ineff= 4 ,-1
    2070    3277  160.29    3277    4536  161.26 5063.72    9773  160.85
    9773 11132.5  165.17
Permanent Ineff=
       T       T       T       T
Bank Sta=4926,5033.5
XS Rating Curve= 0
Vertical n Elevations= 2
   143.8     160
Vertical n for Station=178.3
     .24     .24
Vertical n for Station=2998.3
     .48     .48
Vertical n for Station=4926
     .04     .07
Vertical n for Station=5033.5
     .99     .99
Vertical n for Station=5122
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,216172  ,1682.9,1854,1793
BEGIN DESCRIPTION:
Cross Section K100-00-00-X84
END DESCRIPTION:
XS GIS Cut Line= 4
 2982781.294440813912606.3854149      2984116.81     13909404.81
       2984203.3     13909202.82 2985128.1526744 13902799.273491
#Sta/Elev= 30
  1428.4   164.9  2478.4   160.6  2818.4   156.6  3978.1  156.06  4878.4   155.6
  4927.4   162.1  4947.4   158.7  4954.5  153.08  4967.2  152.18  4985.1  147.22
  4985.5  144.39  5000.6  141.67  5021.1  147.78    5027   152.5  5048.6  155.04
  5061.1  159.04  5075.7  158.97  5077.4   156.7  5107.4   153.5  5157.1   155.3
  5197.1   153.2  5391.3  153.77  5567.1   155.8  6447.1     158  6507.1   156.8
 11447.1   158.4 11547.1   159.9 11567.1   158.4 11587.1   160.4 11587.1  161.71
#Mann= 6 ,-1 , 0
  1428.4     .06       0  3978.1     .14       0  4954.5     .12       0
  4967.2     .04       0    5027     .14       0  5391.3     .06       0
#XS Ineff= 2 , 0
         4600.06  160.97  5061.1          159.04
Permanent Ineff=
       T       T
Bank Sta=4954.5,5027
XS Rating Curve= 0
Vertical n Elevations= 2
  141.67  159.45
Vertical n for Station=1428.4
     .24     .24
Vertical n for Station=3978.1
     .99     .99
Vertical n for Station=4954.5
     .04     .07
Vertical n for Station=5027
     .99     .99
Vertical n for Station=5391.3
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,214318  ,577.7,810,801.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X82
END DESCRIPTION:
XS GIS Cut Line= 4
      2982519.11     13915124.57       2985970.5     13909720.43
       2985995.2     13909473.46  2985999.72185713902843.4593877
#Sta/Elev= 30
 -1538.4     170   611.6   165.3  3241.6   154.8  3535.1  155.77  3561.6   158.9
  3651.6   155.7  4878.7  156.59  4922.2  161.86  4936.3  155.32    4961  153.73
  4968.9  149.77  4986.6  148.67  4995.2  140.77  5010.4  142.46  5036.1  153.59
  5058.5  155.64  5071.5  159.29  5088.4  159.35  5093.8   156.4    5122   153.3
  5168.7  154.07    5962   157.9    7582   159.8    8402   159.4    8912   154.9
    9412   158.8   10932     160   11742   158.2   11752   158.6   11752   160.3
#Mann= 6 ,-1 , 0
 -1538.4     .06       0  3535.1     .12       0  4878.7     .14       0
    4961     .04       0  5036.1     .14       0  5168.7     .06       0
#XS Ineff= 2 , 0
         3705.66  160.98 5088.36          159.35
Permanent Ineff=
       T       T
#Block Obstruct= 2 ,-1
    8500    9500     158   14000   16000     150
Bank Sta=4961,5036.1
XS Rating Curve= 0
Vertical n Elevations= 2
  140.77  158.63
Vertical n for Station=-1538.4
     .24     .24
Vertical n for Station=3535.1
     .48     .48
Vertical n for Station=4878.7
     .99     .99
Vertical n for Station=4961
     .04     .07
Vertical n for Station=5036.1
     .99     .99
Vertical n for Station=5168.7
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,213508  ,1051.8,1654,1717.9
BEGIN DESCRIPTION:
Cross Section XS81
END DESCRIPTION:
XS GIS Cut Line= 4
      2983837.73      13913199.7      2986777.75     13909805.95
      2986791.87     13909594.15  2986809.07987813904634.1582126
#Sta/Elev= 30
     400   164.5    1080   162.7    2160   155.3    3440   155.2    3480     155
    3530   157.7    3620   155.7    4280   155.3  4936.3  155.32  4960.1     154
  4968.9  149.38  4986.6  148.28  4995.2  140.38  5005.1  140.43  5020.3  147.24
    5028  148.38  5040.1   153.2  5080.1   155.4  5122.4   152.7  5142.4   153.3
  5672.4   153.7  5742.4   155.7  5812.4   155.8  5862.4   158.6  5922.4   156.4
  5982.4   156.3  6782.4   158.5  8592.4   158.1 10022.4   158.7 10062.4   159.8
#Mann= 7 ,-1 , 0
     400     .06       0    3440     .12       0    4280     .14       0
  4936.3     .12       0  4960.1     .04       0  5040.1     .14       0
  5142.4     .06       0
#XS Ineff= 2 , 0
         4100.26  156.19 5080.09           155.4
Permanent Ineff=
       T       T
Bank Sta=4936.3,5040.1
XS Rating Curve= 0
Vertical n Elevations= 2
  140.38  158.21
Vertical n for Station=400
     .24     .24
Vertical n for Station=3440
     .48     .48
Vertical n for Station=4280
     .99     .99
Vertical n for Station=4960.1
     .04     .07
Vertical n for Station=5040.1
     .99     .99
Vertical n for Station=5142.4
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,211854  ,2848.8,1768,1451
BEGIN DESCRIPTION:
Cross Section K100-00-00-X80
END DESCRIPTION:
XS GIS Cut Line= 4
      2983957.04     13913175.38      2988206.92     13910203.66
      2988398.64     13909979.98 2988194.683870213904833.9910704
#Sta/Elev= 30
  -345.7   164.4   504.3   161.8  1744.3   155.4  2364.3   154.6  2494.3   155.3
  3434.3   153.6  3574.3     154    3603  155.15  4779.6   155.9  4860.1   151.7
  4959.3  153.02  4993.8  147.36  4997.4  139.59  5030.6  144.36  5048.2  150.64
  5075.2  152.57  5102.7  158.55  5114.9  158.34  5134.7     152  5154.7   150.6
    5189  152.43  5214.7   153.8  5444.7     156  5724.7   156.3  5764.7   155.2
  6434.7   158.4  7134.7   157.6  8464.7   159.1  9664.7   158.2 10284.7   159.2
#Mann= 6 ,-1 , 0
  -345.7     .06       0    3603     .12       0  4779.6     .14       0
  4959.3     .04       0  5048.2     .14       0    5189     .06       0
#XS Ineff= 2 , 0
         4194.59   156.2 5103.49          158.54
Permanent Ineff=
       T       T
Bank Sta=4959.3,5048.2
XS Rating Curve= 0
Vertical n Elevations= 2
  139.59  157.76
Vertical n for Station=-345.7
     .24     .24
Vertical n for Station=3603
     .48     .48
Vertical n for Station=4779.6
     .99     .99
Vertical n for Station=4959.3
     .04     .07
Vertical n for Station=5048.2
     .99     .99
Vertical n for Station=5189
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,210086  ,773.4,857,1080.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X78
END DESCRIPTION:
XS GIS Cut Line= 4
 2989224.656850413916509.8401466      2989389.21     13911545.72
      2989644.84      13910938.6 2989260.383822713906947.0224789
#Sta/Elev= 30
    -294   165.5     546   160.8     796   158.8     826   157.1    2496   154.5
    3386   155.6    3956   152.6    4056     154    4226   152.1    4456   153.3
    4717  152.03  4938.6  150.74  4986.3  148.99  4994.7  139.11  4999.2  138.84
  5005.3  139.15  5011.9   142.4  5017.5  148.43    5053  151.28  5074.6  153.78
  5086.4  159.48  5111.5   159.5  5122.8   153.5  5142.8   151.7  5971.6   151.5
  6197.3  153.48  6661.6   157.8  9201.6   158.8  9231.6   157.2  9341.6   158.9
#Mann= 6 ,-1 , 0
    -294     .06       0    4717     .14       0  4938.6      .1       0
  4986.3     .04       0    5053     .14       0  6197.3     .06       0
#XS Ineff= 2 , 0
         3386.62  155.58 5109.63          159.49
Permanent Ineff=
       T       T
Bank Sta=4986.3,5053
XS Rating Curve= 0
Vertical n Elevations= 2
  138.84  157.17
Vertical n for Station=-294
     .24     .24
Vertical n for Station=4717
     .99     .99
Vertical n for Station=4938.6
     .04     .07
Vertical n for Station=5053
     .99     .99
Vertical n for Station=6197.3
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1
