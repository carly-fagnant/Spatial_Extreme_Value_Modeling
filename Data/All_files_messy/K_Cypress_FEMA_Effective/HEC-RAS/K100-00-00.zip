HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 2 ,266035  ,,,
BEGIN DESCRIPTION:
HEBERT RD
Structure ID: K100-00-00-S34
Prelimnary model: possible spillage to K172 on LOB
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,40,2.6,0, 187, 186, , , .95, 0, ,,,
  -622.3  -352.3   507.7   587.7  1157.7  1167.7  1207.7  1487.7  1833.4  1903.4
  1963.4  1992.1  2053.4  2083.4  2093.4  2103.4  2153.4  2183.4  2373.4  2453.4
  2487.1  2583.4  3247.1  3497.1  3517.1  3547.1  3604.5  3877.1  4223.4  4273.4
  4313.4  4343.4  4363.4  4633.4  4663.4  4777.1  4788.5    4873  4878.5  4903.3
  4927.1  4941.6  4974.1  4981.4  4990.3  4991.5  4998.3  4998.9  5008.1  5009.7
  5016.2  5031.1  5042.5  5075.1  5081.4  5116.5    5128  5226.3  5303.2  5492.5
  5754.3  5817.3  6285.2  6873.2    7081  7113.2  7143.2  7203.2  7233.2  7723.2
  7743.2  7853.2  8213.2  8521.2  8553.2  8663.2  8913.2  8943.2  8963.2  8973.2
  9243.2  9273.2  9346.7 10903.2 10923.2 10943.2 10953.2 10963.2 10973.2 10983.2
 10993.2 11003.2 11013.2 11023.2 11043.2 11613.2 11633.2 11673.2 11693.2 11703.2
 11733.2 11793.2 11813.2 11843.2 11853.2 11963.2 12003.2 12063.2 12143.2 12153.2
 12183.2 12203.2 12233.2 12243.2 12433.2 12453.2 12473.2 12593.2 12633.2 12653.2
 12673.2 12693.2 12723.2 12743.2 12753.2 12773.2 12843.2 12873.2 12903.2 13023.2
 13173.2 13233.2 13253.2 13263.2 13323.2 13413.2 13423.2 13443.2 13453.2 13493.2
 13513.2 13673.2 13693.2 13723.2 13773.2 13783.2 13793.2 13813.2 13823.2 13833.2
 13843.2 13863.2 13873.2 13893.2 13903.2 13923.2 13933.2 13953.2 13983.2 14003.2
 14053.2 14073.2 14103.2 14113.2 14213.2 14233.2 14273.2 14323.2 14383.2 14453.2
 14483.2 14573.2 14673.2 16883.2 16903.2 16913.2 16923.2 16953.2 16963.2 16983.2
 16993.2 17003.2 17043.2 17053.2 17063.2 17073.2 17782.8
   176.2   174.9   175.2   174.6   173.6   173.3   174.2   174.5   174.8   174.7
   172.8  172.61   172.2   172.3   172.6   173.5   173.8   174.3   173.7   175.8
  175.68  175.31  175.19  175.14  175.14  175.13  175.12  175.07  175.12  175.81
  175.41  176.21  175.91  177.11  176.61  177.25  177.31  177.55   177.6  177.75
  177.91  178.07  178.44  178.49  178.55  178.56  178.61  178.61  178.54  178.53
  178.49  178.39  178.32  178.14   178.1     178  178.11   177.7  177.31  177.23
  177.11  177.08  176.87   176.6   177.9   178.1   177.3   177.1   175.9   175.7
   176.1   176.1   175.7  175.97     176   175.9   176.6   177.1   177.1   177.5
   177.1   177.9  177.99     180   181.3   181.3   181.8   181.9   181.3   179.7
   178.9   178.9   179.9     180   179.4     179   179.7     180   181.4   181.4
   179.8   179.8   179.6   179.9   179.5   179.5   179.3   179.8   179.3   179.7
   179.3   179.8   179.6   179.8   179.7   179.2   179.7   179.5   179.2   179.4
     179   179.6   179.2   179.4   179.1   179.1   178.4   178.8   178.5   178.6
     179   178.5     179   178.8   179.2   179.3     179   179.4   179.2   179.7
   179.3     180   179.6   180.1   179.6   180.5   180.9   180.9   180.4   179.3
   179.9   182.4     185   185.7   184.2   180.1   180.5   179.5   179.6     179
   179.9   179.5     180   180.4   181.1   180.9   181.2   180.2   180.4   180.4
   179.6   180.4   179.1   184.4   185.1     185   184.4   184.3     185   185.3
   184.6   184.8   188.8   189.1   188.9   188.2   187.8
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                        
  -352.3   507.7   587.7  1157.7  1167.7  1207.7  1487.7  1833.4  1903.4  1963.4
  1992.1  2053.4  2083.4  2093.4  2103.4  2153.4  2183.4  2373.4  2453.4  2487.1
  2583.4  3247.1  3497.1  3517.1  3547.1  3604.5  3877.1  4223.4  4273.4  4313.4
  4343.4  4363.4  4633.4  4663.4  4777.1  4788.5    4873  4878.5  4903.3  4927.1
  4941.6  4974.1  4981.4  4990.3  4991.5  4998.3  4998.9  5008.1  5009.7  5016.2
  5031.1  5042.5  5075.1  5081.4  5116.5    5128  5226.3  5303.2  5492.5  5754.3
  5817.3  6285.2  6873.2    7081  7113.2  7143.2  7203.2  7233.2  7723.2  7743.2
  7853.2  8213.2  8521.2  8553.2  8663.2  8913.2  8943.2  8963.2  8973.2  9243.2
  9273.2  9346.7 10903.2 10923.2 10943.2 10953.2 10963.2 10973.2 10983.2 10993.2
 11003.2 11013.2 11023.2 11043.2 11613.2 11633.2 11673.2 11693.2 11703.2 11733.2
 11793.2 11813.2 11843.2 11853.2 11963.2 12003.2 12063.2 12143.2 12153.2 12183.2
 12203.2 12233.2 12243.2 12433.2 12453.2 12473.2 12593.2 12633.2 12653.2 12673.2
 12693.2 12723.2 12743.2 12753.2 12773.2 12843.2 12873.2 12903.2 13023.2 13173.2
 13233.2 13253.2 13263.2 13323.2 13413.2 13423.2 13443.2 13453.2 13493.2 13513.2
 13673.2 13693.2 13723.2 13773.2 13783.2 13793.2 13813.2 13823.2 13833.2 13843.2
 13863.2 13873.2 13893.2 13903.2 13923.2 13933.2 13953.2 13983.2 14003.2 14053.2
 14073.2 14103.2 14113.2 14213.2 14233.2 14273.2 14323.2 14383.2 14453.2 14483.2
 14573.2 14673.2 16883.2 16903.2 16913.2 16923.2 16953.2 16963.2 16983.2 16993.2
 17003.2 17043.2 17053.2 17063.2 17073.2 17782.8
   174.9   175.2   174.6   173.6   173.3   174.2   174.5   174.8   174.7   172.8
  172.61   172.2   172.3   172.6   173.5   173.8   174.3   173.7   175.8  175.68
  175.31  175.19  175.14  175.14  175.13  175.12  175.07  175.12  175.81  175.41
  176.21  175.91  177.11  176.61  177.25  177.31  177.55   177.6  177.75  177.91
  178.07  178.44  178.49  178.55  178.56  178.61  178.61  178.54  178.53  178.49
  178.39  178.32  178.14   178.1     178  178.11   177.7  177.31  177.23  177.11
  177.08  176.87   176.6   177.9   178.1   177.3   177.1   175.9   175.7   176.1
   176.1   175.7  175.97     176   175.9   176.6   177.1   177.1   177.5   177.1
   177.9  177.99     180   181.3   181.3   181.8   181.9   181.3   179.7   178.9
   178.9   179.9     180   179.4     179   179.7     180   181.4   181.4   179.8
   179.8   179.6   179.9   179.5   179.5   179.3   179.8   179.3   179.7   179.3
   179.8   179.6   179.8   179.7   179.2   179.7   179.5   179.2   179.4     179
   179.6   179.2   179.4   179.1   179.1   178.4   178.8   178.5   178.6     179
   178.5     179   178.8   179.2   179.3     179   179.4   179.2   179.7   179.3
     180   179.6   180.1   179.6   180.5   180.9   180.9   180.4   179.3   179.9
   182.4     185   185.7   184.2   180.1   180.5   179.5   179.6     179   179.9
   179.5     180   180.4   181.1   180.9   181.2   180.2   180.4   180.4   179.6
   180.4   179.1   184.4   185.1     185   184.4   184.3     185   185.3   184.6
   184.8   188.8   189.1   188.9   188.2   187.8
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Culvert=1,7,,40,.014,.9,1,1,3,169.89,4991.5,170.18,4991.5,Culvert #1  , 0 ,10
Culvert Bottom n=.014
Culvert=1,7,,40,.014,.9,1,1,3,169.89,5003,170.18,5003,Culvert #2  , 0 ,10
Culvert Bottom n=.014
BR U #Sta/Elev= 30
 -2963.8  173.72 -2553.8   172.5  -583.8   176.2  1833.2  174.81  2083.2  172.03
  2453.4  175.81  4223.4  175.01  4981.4  177.03  4991.5  169.89  5004.3   170.1
  5016.2  176.95  7113.2  178.11  7233.2  175.91  8521.2  175.98 10903.2  180.01
 10963.2  181.91 10993.2  178.91 11613.2  179.01 11693.2  181.41 12843.2  178.41
 13833.2  179.31 13893.2  185.71 13923.2  180.11 14003.2  179.01 14273.2  181.21
 14673.2  179.11 16953.2  184.31 17003.2  184.81 17053.2  189.11 17782.8  187.81
BR U #Mann= 5
 -2963.8     .06 -2553.8     .14  4981.4     .08  5016.2     .12  8521.2     .06
BR D #Sta/Elev= 30
 -2995.8   173.5 -2645.8  171.91  -945.8  174.86    1824  174.84    2044  172.24
    2354  173.53  2453.4  176.44  4981.4  177.66  4991.5  170.18  5004.3  170.39
  5016.2  177.58  7113.2  178.74  7233.2  176.54  8521.2  176.61 10903.2  180.64
 10963.2  182.54 10993.2  179.54 11613.2  179.64 11693.2  182.04 12843.2  179.04
 13833.2  179.94 13893.2  186.34 13923.2  180.74 14003.2  179.64 14273.2  181.84
 14673.2  179.74 16953.2  184.94 17003.2  185.44 17053.2  189.74 17782.8  188.44
BR D #Mann= 5
 -2995.8     .06  -945.8     .14  4981.4     .08  5016.2     .12  8521.2     .06
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=189.11

Type RM Length L Ch R = 1 ,266005  ,78.4,89,80.3
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
LOB spills to K172-00-00.
END DESCRIPTION:
XS GIS Cut Line= 5
      2961021.43      13904215.7       2957534.1     13900888.72
      2954633.19     13900287.38      2954116.86     13900268.99
        2941637.     13900216.73
#Sta/Elev= 30
 -2995.8   173.5 -2645.8  171.91  -945.8  174.86    1824  174.84    2044  172.24
    2354  173.53  2453.4  176.44  4981.4  177.66  4998.9  171.56  5008.1   172.3
  5016.2  177.58  7113.2  178.74  7233.2  176.54  8521.2  176.61 10903.2  180.64
 10963.2  182.54 10993.2  179.54 11613.2  179.64 11693.2  182.04 12843.2  179.04
 13833.2  179.94 13893.2  186.34 13923.2  180.74 14003.2  179.64 14273.2  181.84
 14673.2  179.74 16953.2  184.94 17003.2  185.44 17053.2  189.74 17782.8  188.44
#Mann= 5 ,-1 , 0
 -2995.8     .05       0  -945.8     .14       0  4981.4     .08       0
  5016.2     .14       0  8521.2     .06       0
#XS Ineff= 2 , 0
       0    4988   173.6 5006.51       0   173.6
Permanent Ineff=
       F       F
Bank Sta=4981.4,5016.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,265916. ,175.8,220,191.1
BEGIN DESCRIPTION:
K100-00-00-S34_HERBERT -DS - XS1
LOB spills to K172-00-00.
END DESCRIPTION:
XS GIS Cut Line= 5
      2961055.71      13904147.1      2957476.73     13900796.64
      2954625.78     13900207.38      2954109.45     13900188.99
      2941629.59     13900136.73
#Sta/Elev= 30
 -3049.7  173.13  -129.7  175.73  1090.3  173.64  1846.9   174.8  1882.9  172.33
  1932.9  174.23  2002.9  171.22  2092.9  173.73  2522.9  175.67  3872.9  173.02
  4764.1   176.1  4981.4  177.57  4998.9  171.47  5008.1  172.21  5016.2  177.49
  7460.8   176.1  9180.8  176.58 10880.8   180.1 10920.8  182.64 10970.8  178.35
 11060.8  180.16 13250.8  178.72 13830.8  181.51 14040.8  179.17 14650.8  179.14
 16900.8  183.83 16970.8  185.78 17000.8  191.15 17030.8   188.2 17760.8  187.61
#Mann= 6 ,-1 , 0
 -3049.7     .05       0  2002.9      .1       0  4764.1     .14       0
  4981.4     .08       0  5016.2     .12       0  7460.8     .06       0
Bank Sta=4981.4,5016.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,265696  ,809,1531,1417.7
BEGIN DESCRIPTION:
Cross Section XS112.3
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 6
      2961124.26      13904104.3      2957405.96     13900651.96
      2954741.47     13900013.48      2954484.33     13900002.56
      2954474.07     13900000.75      2941644.95     13899942.66
#Sta/Elev= 30
 -3076.4  173.33   273.6  175.64  1729.4   174.8  1909.4   172.3  1959.4   174.1
  2027.5   171.3  2177.5     174  2477.5   174.2  4107.5   173.2  4981.4  177.35
  4998.9  171.25  5008.1  171.99  5016.2  177.27  5480.7  176.99  6575.2   176.8
  9735.2   176.4 10995.2   180.9 11045.2   177.2 11065.2   179.9 11145.2   180.3
 13395.2   178.6 13915.2   179.7 14025.2   183.2 14095.2   179.6 14685.2   178.9
 15285.2   182.1 16965.2   184.3 17045.2   185.1 17085.2   190.1 17834.5   187.6
#Mann= 6 ,-1 , 0
 -3076.4     .05       0  2477.5     .14       0  4981.4     .08       0
  5016.2     .14       0  5480.7     .12       0  6575.2     .06       0
Bank Sta=4981.4,5016.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,264165  ,467.1,1249,1158.4
BEGIN DESCRIPTION:
Cross Section k100-00-00-X112
Prelimnary model: possible spillage to K172 on LOB
END DESCRIPTION:
XS GIS Cut Line= 5
      2961304.21      13903110.3      2957422.34     13900582.36
       2954838.1      13898545.6      2954475.63     13898768.88
      2942795.76     13897290.23
#Sta/Elev= 30
 -3220.7  172.92 -2850.7  171.72 -2540.7  174.15    39.3  172.66  1351.2  173.82
  1397.4   171.4  1705.9  173.12  2780.6  173.26  3757.4   173.6  3837.4   175.2
  4027.4   173.4  4398.3  173.76  4961.5  173.83  4998.6  169.69  5029.3   173.7
  5086.5  173.62  5127.9   176.8    6459  174.71 11337.9   179.1 11717.9   178.1
 11817.9   180.1 11857.9   178.4 11887.9   180.5 13137.9   182.1 13857.9   180.6
 14467.9   182.8 14507.9   181.3 15407.9   182.6 15827.9   181.3   16901   185.9
#Mann= 8 ,-1 , 0
 -3220.7     .05       0  1351.2     .12       0  1705.9     .06       0
  2780.6     .07       0  4398.3     .14       0  4961.5      .1       0
  5029.3     .14       0    6459      .1       0
Bank Sta=4961.5,5029.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,262916  ,521.5,482,413.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X111
Prelimnary model: possible spillage to K172 on LOB
END DESCRIPTION:
XS GIS Cut Line= 6
       2961364.2      13902810.3      2957551.22     13900179.17
      2954362.39       13897626.      2954195.21     13897636.45
      2948116.67      13896219.8      2946614.53     13895640.41
#Sta/Elev= 30
 -3827.6  172.77   172.4  172.88   252.4  170.28   782.4  173.21   815.1  170.92
   855.1  172.77  2121.3   174.5  2161.3   172.5  2181.5   173.9  4020.2   174.7
  4331.3   174.5  4411.3   176.6  4501.3   174.5  4984.9  173.96  4989.5  173.17
  4994.6  168.31  4999.3  168.21    5013  169.32  5016.3  172.49  5021.2  173.72
  5199.9  175.14  8020.7  175.58  8627.6   177.3  9687.6     176 10387.6   179.6
 11479.1   181.5 11529.1   183.1 11559.1   181.6 11589.1   183.3 12909.1   184.5
#Mann= 7 ,-1 , 0
 -3827.6     .05       0  2181.5     .12       0  4020.2     .14       0
  4984.9      .1       0  5021.2     .14       0  5199.9     .12       0
  8020.7     .06       0
Bank Sta=4984.9,5021.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,262434  ,1045.9,1987,2154.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X110
Prelimnary model: possible spillage to K172 on LOB
END DESCRIPTION:
XS GIS Cut Line= 5
      2961355.63      13902527.5       2957683.2     13899815.45
      2954853.48     13897294.26      2954156.03     13897278.58
      2949576.17     13895150.73
#Sta/Elev= 30
   -3657  172.79   -3377  171.14   -1047   172.6    -247   170.4     858   172.5
     918     170     958   172.2    2218   172.9    2258   174.9  2337.5  174.64
    2388   171.9    2568   171.2    2598   173.2    2628   171.5    3208   172.8
    3268   175.7    3298   173.2    3428   174.7    3468   172.6    3548   172.3
    3668   174.7  4175.3  172.74    4980  173.18  4992.1  166.64  5007.9  166.75
  5015.8  173.29  5549.7  174.89  6457.6  174.93  9235.9   176.4 10445.9   179.7
#Mann= 7 ,-1 , 0
   -3657     .05       0  2337.5     .12       0  4175.3     .14       0
    4980      .1       0  5015.8     .14       0  5549.7     .12       0
  6457.6     .06       0
Bank Sta=4980,5015.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,260447  ,659.9,1110,828.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X109
Prelimnary model: possible spillage to K172 on LOB
END DESCRIPTION:
XS GIS Cut Line= 6
      2961689.83      13902527.5      2957878.74     13899192.48
      2955471.59     13895974.54      2955122.79     13895712.37
      2952869.82     13894022.97      2950550.11     13893333.58
#Sta/Elev= 30
   -4377   172.4   -3357  170.91   -2527  170.63   -1697  173.42   -1367   170.5
    -837  170.07     583  170.54     633  172.22     663   169.7   757.3  172.43
  2613.7   170.1  2653.7   171.7  2693.7     170  3603.7   171.4  3633.7   173.5
  3723.7   173.9  3773.7   171.7  3913.7   173.4  4444.3  171.88  4980.9  172.97
  4996.6  167.42    5014  166.99  5024.5     172    5126   173.8  5620.9  173.17
  5822.3   174.9  5892.3     173  6559.3  172.54  7958.3     173 10378.3   178.7
#Mann= 7 ,-1 , 0
   -4377     .05       0   -3357     .12       0  4444.3     .14       0
  4980.9      .1       0  5024.5     .14       0  5620.9     .12       0
  6559.3     .05       0
Bank Sta=4980.9,5024.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,259337  ,1024,1704,1098.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X108
Prelimnary model: possible spillage to K172 on LOB
END DESCRIPTION:
XS GIS Cut Line= 6
      2961775.52       13902279.       2958060.6     13898776.94
      2955932.09     13895281.51      2955724.64     13895153.84
      2952550.28     13892704.86      2950628.65     13892115.56
#Sta/Elev= 30
 -4301.6  172.21 -3631.6  172.45 -3411.6  170.54 -2621.6  170.36 -1871.6  173.93
 -1801.6  170.99 -1781.6  171.99  -501.6  169.74   779.8   171.4   819.8   169.4
   899.8   171.4  2616.3   170.9  2639.8   169.9  2699.8   170.9  3029.8   170.1
  3069.8   171.2  3219.8   170.1  3499.8     171  3539.8   173.5  3609.8   171.5
  4984.8  171.81  4999.7  165.34  5010.4  165.45 5015.21  171.69  5026.4   173.1
  5113.5  171.08    5200   172.2  6814.4  171.84  9219.2   173.1 11159.2   178.2
#Mann= 5 ,-1 , 0
 -4301.6     .05       0  2616.3     .12       0  4984.8      .1       0
 5015.21     .14       0  6814.4     .05       0
Bank Sta=4984.8,5015.21
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,257633  ,221.8,1285,1753.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X107
Prelimnary model: possible spillage to K172 on LOB
END DESCRIPTION:
XS GIS Cut Line= 6
      2962058.31      13901327.8      2958355.92     13898013.78
      2956780.69     13893893.83      2955936.06     13893899.39
      2952749.99      13891985.9      2950740.78      13891278.8
#Sta/Elev= 30
 -5116.6  172.68 -4606.6   170.2 -4116.6  171.18 -4036.6  169.33  -156.4   169.9
  -126.4   168.3   -66.4   170.3    93.6   170.6   663.6   170.2   683.6   168.8
   923.6   170.2  2828.3   169.8  2853.6   168.7    3723  169.89  4263.2   171.4
  4473.2   169.9  4978.3  169.97  4992.3  163.37  5002.5   162.1  5007.6  163.29
  5014.4  171.14  5580.8  169.51  5892.9   169.9  5982.9   171.9  6042.9   170.6
  8232.9   174.1  8622.9   171.6  8762.9   168.6  8802.9   172.8 11029.4   178.8
#Mann= 6 ,-1 , 0
 -5116.6     .05       0  2828.3     .12       0    3723     .14       0
  4978.3      .1       0  5014.4     .14       0  5580.8     .05       0
#Block Obstruct= 2 ,-1
    8400    8805   172.8    9000    9100     100
Bank Sta=4978.3,5014.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,256348  ,546.6,749,370.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X106
Prelimnary model: possible spillage to K172 on LOB
END DESCRIPTION:
XS GIS Cut Line= 6
      2962049.74      13900976.5      2958444.17     13897716.23
      2957069.64     13894049.42      2956408.38     13892843.59
      2955769.35     13891876.71      2950685.44     13889002.78
#Sta/Elev= 30
 -4950.9  171.29 -4550.9   171.5 -4430.9  169.51 -4360.9  170.36 -1270.9  168.25
  -138.6   169.6   -88.6   167.4   -38.6   169.8   391.4   170.1   421.4   169.1
  1041.4   170.2  2559.4  169.14  3455.6   170.7  3826.2   169.8  4176.8   171.5
  4740.1  169.23  4975.2  170.14    4996   162.7  5000.5  162.13  5029.9  169.92
  5361.6   169.3  6390.4   168.5  6660.4   170.5  8490.4   171.9  9080.4   173.8
  9150.4   172.9 10460.4   173.4 10570.4   174.5 12110.4   176.8 12200.4     178
#Mann= 8 ,-1 , 0
 -4950.9     .05       0  2559.4     .12       0  3455.6     .14       0
  4176.8     .12       0  4740.1     .14       0  4975.2      .1       0
  5029.9     .14       0  5361.6     .05       0
Bank Sta=4975.2,5029.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,255599  ,877,1512,1753.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X105
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 5
      2962024.03      13900350.9      2958667.96     13897202.55
      2957343.37     13892824.69      2956864.06     13892385.32
      2951632.17     13887810.45
#Sta/Elev= 30
 -4474.4  170.52 -2564.4   168.2   123.7   169.2   173.7   167.5   243.7   169.5
   403.7   169.7  2133.7   169.9  2173.7   168.3  2193.7   169.5  2233.7   168.7
  2253.7   170.2  2553.7     170  2686.7  171.18  2713.7   172.2  2743.7     169
  2773.7   168.1  3853.7   170.6  4183.7   168.6    4708  168.64  4980.4  169.88
  4991.3  162.88  5005.7  161.83  5026.9  169.81  5595.8  168.68  6821.4     169
  8021.4   171.9  8811.4   170.9  9891.4   173.4 10151.4   172.6 12301.4   176.1
#Mann= 6 ,-1 , 0
 -4474.4     .05       0  2686.7     .12       0    4708     .14       0
  4980.4      .1       0  5026.9     .14       0  5595.8     .05       0
#Block Obstruct= 2 ,-1
     123     243   169.2    2600    2700     100
Bank Sta=4980.4,5026.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,254087  ,794.8,1714,3567.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X104
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 5
      2962195.42      13899931.1      2959075.55     13895994.98
      2958346.61     13891739.07      2958113.89     13891462.14
      2953521.56     13886325.75
#Sta/Elev= 30
 -4436.2  170.08  -586.2  167.76   521.1   169.6   591.1   166.2   681.1   169.4
  1301.1   168.9  1331.1   167.5  1351.1   168.8  3051.1   168.8  3091.1   170.5
  3191.1   169.4  3371.1   170.5  3481.1   176.4  3541.1   177.2  3631.1   171.4
  4904.2   171.1  4914.2   172.3    4930   177.1  4987.7  165.15  4988.4  162.44
  4992.7   161.5  5008.5  160.56  5019.6  171.53  5064.2   169.1  5295.9   168.8
  5385.9     167  7875.9   170.3  9055.9     170 12075.9   174.3 12155.9   175.7
#Mann= 5 ,-1 , 0
 -4436.2     .05       0  4904.2     .14       0    4930      .1       0
  5019.6     .14       0  5064.2     .05       0
#Block Obstruct= 2 ,-1
     522     681     166    2600    2700     100
Bank Sta=4930,5019.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,252373  ,385.5,727,691.4
BEGIN DESCRIPTION:
Cross Section XS103.6
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 6
      2962349.66       13899614.      2959719.78     13895783.37
      2959619.18     13891016.19      2959632.01     13890875.05
      2959767.72     13886564.38      2958129.44     13883932.61
#Sta/Elev= 30
 -4493.9  169.47 -1613.9  167.24   592.6  168.51   622.7   170.2   652.7   166.1
   682.7   168.8   712.7   166.7  2372.7     168  2442.7   169.8  2522.7   168.1
  2662.7   170.2  2962.7   168.5  4940.9   168.2  4970.9   169.7  4983.6  165.42
  4989.6  159.55  5010.6  160.08  5020.9   164.8  5040.9   169.3  5060.9   167.5
  5602.7   169.3  5962.7   167.2  6012.7   169.2  6532.7   168.7  6662.7   164.1
  6692.7   167.2 10945.5     169 11005.5   170.6 12415.5   169.6 12475.5   173.4
#Mann= 3 ,-1 , 0
 -4493.9     .05       0  4970.9     .08       0  5040.9     .05       0
Bank Sta=4970.9,5040.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,251646. ,110.9,119,84
BEGIN DESCRIPTION:
K100-00-00-S33_PRIVATE RD -US - XS4
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 6
      2962495.34      13899485.5      2960029.05     13895732.63
       2960303.6     13891167.78      2960356.12     13889143.06
      2960553.29      13886574.5      2957418.28      13881092.3
#Sta/Elev= 30
 -4018.7  169.36  -808.7  167.08   883.8  169.75   913.8  165.76   933.8  168.81
   963.8  166.42  3023.8  170.07  4923.8  169.16  4953.9  170.31  4973.9  167.37
 4983.29  164.96 4988.47  159.12 5007.98  160.48  5013.9   166.4  5033.9  169.37
  5063.1  167.94  5853.1  167.84  5893.1  170.17  5953.1  167.61  6253.1  169.87
  6443.1   167.2  6523.1   169.7  6843.1  168.87  6923.1  164.45  7088.5  166.98
  9388.5  169.43 12604.6     169 12954.6   169.7 13034.6  173.14 15979.9  175.99
#Mann= 5 ,-1 , 0
 -4018.7      .2       0  4923.8      .4       0  4973.9     .08       0
  5013.9      .4       0  5063.1      .2       0
Bank Sta=4973.9,5013.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,251527  ,51.8,52,48.3
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 6
      2962581.03      13899451.2      2960126.23     13895697.66
      2960355.16     13891542.82      2960437.89     13889171.12
      2960635.06     13886602.56      2957500.05     13881120.36
#Sta/Elev= 30
 -3895.1  169.36  -525.1  166.97   958.4  169.51   988.4  165.31  1018.4  168.71
  1048.4  167.01  2568.4  167.61  3118.4  170.21  4288.4  169.11  4759.1  165.63
  4922.2  167.14  4977.4  168.88  4989.6  159.05  5010.6  159.58  5014.6  165.55
  5020.1  168.56    5116  167.38  6830.8  168.51  6980.8  164.71  7040.8  167.01
  9700.7  169.41 12550.7  169.01 12630.7  171.7112690.69  169.1112950.71  171.21
13120.69  169.51 13230.7  172.91 14060.7  172.51 14420.7  175.41 16015.9  175.91
#Mann= 5 ,-1 , 0
 -3895.1      .2       0  4922.2     .32       0  4977.4     .08       0
  5020.1     .32       0    5116      .2       0
Bank Sta=4977.4,5020.1
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 2 ,251507  ,,,
BEGIN DESCRIPTION:
PRIVATE RD 1270' US X103
Structure ID: K100-00-00-S33
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,20,2.6,0, 35, 35, , , .95, 0, ,,,
  4751.3  4759.1  4766.5  4809.4  4824.4  4864.1  4880.9  4922.2  4935.7  4977.4
  4983.6  4983.9  4987.7  4989.2  4989.6  4997.9  5000.6  5008.9  5010.6 5010.71
  5012.1  5014.6  5020.1    5059  5061.5  5113.7    5116  5168.3  5170.9  5222.8
  5224.9  5241.3  5250.8  5270.8  5280.8
  166.81  166.27  166.26  166.17  166.14  166.52   166.7  167.46  167.77  168.88
  168.92  168.92  168.97  168.99     169  169.11  169.08  168.99  168.95  168.95
  168.92  168.86  168.73  168.18  168.14  167.38  167.38  167.34  167.34  167.44
  167.03  167.51  167.81  168.11  168.51
                                                                                
                                                                                
                                                                                
                                        
  4751.3  4759.1  4766.5  4809.4  4824.4  4864.1  4880.9  4922.2  4935.7  4977.4
  4983.6  4983.9  4987.7  4989.2  4989.6  4997.9  5000.6  5008.9  5010.6 5010.71
  5012.1  5014.6  5020.1    5059  5061.5  5113.7    5116  5168.3  5170.9  5222.8
  5224.9  5241.3  5250.8  5270.8  5280.8
  166.81  166.27  166.26  166.17  166.14  166.52   166.7  167.46  167.77  168.88
  168.92  168.92  168.97  168.99     169  169.11  169.08  168.99  168.95  168.95
  168.92  168.86  168.73  168.18  168.14  167.38  167.38  167.34  167.34  167.44
  167.03  167.51  167.81  168.11  168.51
                                                                                
                                                                                
                                                                                
                                        
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Culvert=1,7,,30,.014,.9,1,1,3,156.1,4995,156.17,4995,Culvert #1  , 0 ,10
Culvert Bottom n=.014
Culvert=1,2,,30,.014,.9,1,1,3,162.96,5000,162.42,5000,Culvert #2  , 0 ,10
Culvert Bottom n=.014
Culvert=1,7,,30,.014,.9,1,1,3,156.79,5005,156.93,5005,Culvert #3  , 0 ,10
Culvert Bottom n=.014
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=176.51

Type RM Length L Ch R = 1 ,251475  ,108.3,25,103.2
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 6
      2962641.02      13899442.6      2960175.68     13895671.84
      2960402.47     13891556.58      2960485.17     13889184.17
      2960682.79     13886610.99      2957544.73     13881123.46
#Sta/Elev= 30
 -3867.3   169.5  -387.3  166.27  -347.3  168.22   957.9  168.14   977.9  169.77
  1007.9  165.26  1037.9  168.81  1067.9  166.61  3087.9  169.87  4759.1  165.63
  4922.2  167.14  4977.4  168.06  4989.6  158.23  5010.6  158.76  5014.6  164.73
  5020.1  167.74    5116  167.38  6830.8  168.51  6980.8  164.71  7040.8  167.01
  9700.7  169.41 12550.7  169.01 12630.7  171.7112690.69  169.1112950.71  171.21
13120.69  169.51 13230.7  172.91 14060.7  172.51 14420.7  175.41 16015.9  175.91
#Mann= 5 ,-1 , 0
 -3867.3      .2       0  4922.2     .32       0  4977.4     .08       0
  5020.1     .32       0    5116      .2       0
Bank Sta=4977.4,5020.1
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,251450  ,21.4,21,20.1
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 6
       2962675.3      13899399.8      2960296.46     13895697.99
      2960424.23     13891545.17      2960437.77     13891087.63
      2960813.53     13886313.19      2957737.96     13880920.96
#Sta/Elev= 30
 -3764.8  169.37  -134.8  166.48   951.6  167.97   991.6  170.86  1021.6  165.22
  1051.6  168.59  1191.6  168.92  2901.6  167.75  3161.6   170.4  3411.6  167.74
 4783.99  168.83 4799.89  166.45    4939  168.88 4974.39  167.58 4983.79   159.7
 4997.59  157.34 5016.09  159.93 5030.29  168.17 5124.19  167.81  6819.8  167.44
  7009.8  164.49  7259.8  166.92 10034.7  169.86 12584.7  171.18 12644.7  169.07
 12754.7  171.63 13834.7  169.15 13934.7  172.87 14424.7  174.82 16248.5  177.02
#Mann= 5 ,-1 , 0
 -3764.8      .2       0    4939     .56       0 4974.39      .1       0
 5030.29     .56       0 5124.19      .2       0
Bank Sta=4974.39,5030.29
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,251439  ,,,
BEGIN DESCRIPTION:
PL1_K100-00-00-S33a
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,2,2.6,0, 16, 16, , , .95, 0, ,,,
4974.8914977.6014977.6894981.791 4983.19 4983.694983.789 4997.59 5016.09 5016.29
5018.8895021.089 5024.08 5024.19 5026.89  5028.9
  166.99  166.99  166.99  166.98  166.98  166.97  166.97  166.93  166.88  166.88
  166.87  166.87  166.86  166.86  166.86  166.86
  164.99  164.99  164.99  164.98  164.98  164.97  164.97  164.93  164.88  164.88
  164.87  164.87  164.86  164.86  164.86  164.86
4974.8914977.6014977.6894981.791 4983.19 4983.694983.789 4997.59 5016.09 5016.29
5018.8895021.089 5024.08 5024.19 5026.89  5028.9
  166.99  166.99  166.99  166.98  166.98  166.97  166.97  166.93  166.88  166.88
  166.87  166.87  166.86  166.86  166.86  166.86
  164.99  164.99  164.99  164.98  164.98  164.97  164.97  164.93  164.88  164.88
  164.87  164.87  164.86  164.86  164.86  164.86
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=177.62

Type RM Length L Ch R = 1 ,251429  ,85.7,92,80.2
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 6
      2962709.57      13899391.2       2960317.8     13895654.74
      2960444.22     13891545.78      2960457.75     13891088.71
      2960833.95     13886308.63      2957755.33     13880911.05
#Sta/Elev= 30
 -3764.8  169.37  -134.8  166.48   951.6  167.97   991.6  170.86  1021.6  165.22
  1051.6  168.59  1101.6  168.81  2901.6  167.75  3161.6   170.4  3411.6  167.74
  4623.5  167.72    4800  166.45 4940.99  168.89 4974.39  167.58 4983.79   159.7
 4997.59  157.34 5016.09  159.93 5030.29  168.17  5218.9  167.42  6819.8  167.44
  7009.8  164.49  7259.8  166.92 10034.7  169.86 12584.7  171.18 12644.7  169.07
 12754.7  171.63 13834.7  169.15 13934.7  172.87 14424.7  174.82 16248.5  177.02
#Mann= 5 ,-1 , 0
 -3764.8      .2       0  4623.5     .56       0 4940.99      .1       0
 5030.29     .56       0  5218.9      .2       0
Bank Sta=4940.99,5030.29
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,251335  ,1015.1,1233,1365.9
BEGIN DESCRIPTION:
K100-00-00-S33A_PIPELINE -DS - XS1
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 6
      2962752.42      13899374.1      2960398.18     13895646.27
      2960524.27     13891547.91       2960537.8     13891090.84
        2960914.     13886310.76      2957835.39     13880913.18
#Sta/Elev= 30
 -3679.1  169.42    60.9  166.59  1014.6  167.88  1044.6  170.43  1074.6  165.01
  1094.6  168.17  1154.6  169.21  3324.6  170.37  3444.6  167.49  4920.1  168.22
  4940.1  169.61    4983  165.03 4988.28  159.68 5000.22  157.05 5016.09  159.94
 5023.04  164.87  5050.1   168.8  5100.1  166.95  6827.4  167.38  7067.4  164.45
  7107.4   166.5 10182.3  169.93 12592.3  169.54 12652.3  171.67 12682.3  169.31
 12822.3  171.44 14012.3  169.52 14132.3  173.49 14602.3  175.38 16296.1  176.47
#Mann= 5 ,-1 , 0
 -3679.1      .2       0  4920.1      .4       0    4983     .07       0
 5023.04      .4       0  5100.1      .2       0
Bank Sta=4983,5023.04
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,250102  ,613.5,910,641.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X103
LOB spills to K172
END DESCRIPTION:
XS GIS Cut Line= 5
      2962872.39      13899356.9      2961330.71      13895603.7
      2961702.26     13891812.57      2961782.18     13891377.91
       2962480.6     13885360.26
#Sta/Elev= 30
 -3083.3  168.44  1218.8     168  1248.8     164  1278.8   167.3  1308.8   165.9
  1328.8     168  4178.8   168.2  4783.5   167.8  4799.9  165.59  4878.8  165.82
  4922.4  165.86  4932.6  169.81    4949  169.81  4963.1  166.67  4972.7  165.65
    4989  159.38  5001.6  157.39  5012.8  159.31  5017.8  163.62  5052.5  166.69
  5057.5  168.92  5075.6   168.3  5083.5  165.75  5122.1  164.81  5208.7  164.81
  5225.5   166.7  5415.5   165.4  8405.5   166.7 10875.5     169 11283.5   170.8
#Mann= 5 ,-1 , 0
 -3083.3      .2       0  4878.8      .4       0  4963.1     .07       0
  5052.5      .4       0  5122.1      .2       0
#Block Obstruct= 2 ,-1
    1210    1330     168    2600    2700     100
Bank Sta=4963.1,5052.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,249192  ,862,1144,861.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X102
END DESCRIPTION:
XS GIS Cut Line= 5
      2962983.79      13899348.3      2961808.36     13895723.28
      2962629.76     13891930.51      2962652.19     13891529.02
      2962675.92     13885425.36
#Sta/Elev= 30
 -2879.8  169.04 -2409.8   167.9  1288.5   168.2  1328.5   164.6  1348.5   167.4
  1378.5   165.5  1408.5   168.7  1428.5   167.3  1528.5   166.8  3838.5   168.3
  4608.5   167.3  4882.5   166.1  4888.1  164.97  4932.6  170.28  4957.3   165.1
  4963.7  162.57  4977.8  163.05  4999.2  158.77  5006.2  159.29  5014.4  163.04
    5026   165.8  5045.5  167.93  5070.3  167.26  5077.5  165.76    9044   166.7
    9394   169.1   10814   169.1   10994   169.4   11054   170.9 11317.7   170.7
#Mann= 5 ,-1 , 0
 -2879.8      .2       0  4932.6     .32       0  4957.3     .06       0
    5026     .32       0  5077.5      .2       0
#Block Obstruct= 2 ,-1
    1278    1400     168    2600    2700     100
Bank Sta=4957.3,5026
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,248048  ,480.2,833,715
BEGIN DESCRIPTION:
Cross Section K100-00-00-X101
END DESCRIPTION:
XS GIS Cut Line= 5
      2963189.45      13899322.6       2962613.3     13895545.82
      2963789.28     13892013.96       2963759.6     13891509.39
      2962936.33     13885425.36
#Sta/Elev= 30
 -2827.3  168.99  1097.1  166.98  1150.9   169.3  1170.9   163.2  1180.9   162.3
  1210.9   167.3  1240.9   165.2  1290.9   166.4  1640.9   165.4  1660.9   163.9
  1844.7  167.23  4715.7     165  4867.7  165.17  4915.9     168  4933.9   170.8
  4966.5  165.66  5000.7  157.16    5004  157.77  5007.1  161.79  5026.3  161.21
  5035.7  164.85  5074.4  167.82  5088.7  165.94  5143.2  165.17  7231.1   165.8
  7341.1   164.2  9131.1   168.3 11011.1   169.3 11091.1   170.8 11360.6   170.9
#Mann= 6 ,-1 , 0
 -2827.3      .2       0  1097.1      .4       0  1844.7     .24       0
  4915.9      .4       0  4966.5     .06       0  5035.7      .2       0
#Block Obstruct= 2 ,-1
    1140    1958     167    2600    2700     100
Bank Sta=4966.5,5035.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,247215  ,633.3,1706,3492.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X100
END DESCRIPTION:
XS GIS Cut Line= 5
      2963497.95      13899271.2      2963038.04     13895587.69
      2964598.66     13891933.54      2964581.77     13891461.87
      2963170.71     13885360.26
#Sta/Elev= 30
 -2929.3  168.24  1067.3  166.35  1121.7   168.3  1161.7   166.9  1221.7   161.1
  1321.7   167.4  1412.7  167.29    4855  165.11  4905.8  165.58  4930.4  170.48
  4944.1  166.22  4976.7   159.8  4991.8  160.27  4994.5  156.98  5001.2  156.44
  5005.7   156.9  5007.2  160.03  5044.7   165.1  5054.8  167.97  5097.3  165.25
  5898.3   164.4  7248.3   164.7  7728.3   167.6  7818.3   166.8  7838.3   164.6
  7908.3   169.2  7978.3   165.2  8058.3   164.7  8358.3   166.8   11491   170.8
#Mann= 5 ,-1 , 0
 -2929.3      .2       0  1067.3      .4       0  1412.7     .24       0
  4944.1     .06       0  5044.7      .2       0
#Block Obstruct= 2 ,-1
    1100    1342   167.7    2600    2700     100
Bank Sta=4944.1,5044.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,245509  ,255,154,81.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X99
ROB spills into U101-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
      2963695.04      13899245.5      2963729.57     13895539.76
       2964925.5     13892971.67      2965428.39     13892892.96
      2969025.75     13889539.94
#Sta/Elev= 30
   -1774  169.31   -1414  167.79    2072  166.44    2092  165.13  2160.2     167
  2440.2     166  2520.2   162.7  2570.2   166.3  4764.9   165.3  4907.4  167.76
  4913.2   165.5  4931.4  170.55  4962.3  166.07  4990.5  158.97  4992.3  156.31
    4999  155.97  5010.2  158.68  5059.4  164.07  5074.7  168.16  5095.8  165.09
  5103.5   166.9  5178.4  165.26  7803.9   165.8  7883.9   164.4  7903.9   165.9
  7943.9   164.4  8053.9   165.6  8263.9     164  8333.9   165.5 10191.5   166.3
#Mann= 5 ,-1 , 0
   -1774      .2       0  4907.4      .4       0  4962.3     .06       0
  5074.7      .4       0  5178.4      .2       0
#Block Obstruct= 2 ,-1
    2439    2569     166    2600    2700     100
Bank Sta=4962.3,5074.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,245355. ,67.4,79,80
BEGIN DESCRIPTION:
K100-00-00-S99_PIPELINE -US - XS4
ROB spills into U101-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
      2963926.41      13899211.2      2964011.78     13895555.84
      2965075.17     13893142.14      2965401.14     13892989.21
      2969011.36     13889695.72
#Sta/Elev= 30
 -1475.6  169.46  -455.6  167.07  1264.4  166.96  1754.4  165.41  2320.8  166.56
  2350.8  165.27  2390.8  166.67  2410.8  165.28  2425.7  166.87  2735.7  165.72
  2785.7  161.08  2815.7  165.58  2845.7  167.04  4888.4  165.15  4918.4  168.57
  4948.4  166.09 4994.22  156.35 4995.37  154.63  5027.6  159.97 5050.12  166.75
  5068.4  168.62  5098.4  166.08  5168.4  165.44  6888.4  164.67  7718.4  165.92
  8098.4  164.28  8178.4  165.54  8238.4  163.83  8358.4  165.51 10065.2  165.94
#Mann= 5 ,-1 , 0
 -1475.6      .2       0  4888.4      .4       0  4918.4     .06       0
  5068.4      .4       0  5168.4      .2       0
Bank Sta=4918.4,5068.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,245276  ,22.3,23,23.2
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
ROB spills into U101-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
       2964123.5       13899177.       2964093.6     13895536.99
      2965120.18     13893206.84      2965446.15     13893053.91
      2969056.37     13889760.42
#Sta/Elev= 30
 -1368.7  169.21   -28.7  167.04  1111.3  167.15  1801.3  165.28  2391.4  166.51
  2411.4  165.12  2511.4  166.96  2701.4  165.89  2995.3  167.49    4818  165.19
 4873.71  165.81 4884.61  167.42 4961.41  166.77 4973.11  159.22 4992.41  156.51
 4993.51  153.95 5006.61  155.91 5009.31  157.99 5019.41  159.04 5037.51  166.02
 5071.41  167.44    5108   165.4    7278  165.09    7328  165.89    7698  164.79
    8098  165.39    8128  164.39    8198  165.49    8238  164.49 10064.6  166.59
#Mann= 5 ,-1 , 0
 -1368.7      .2       0 4884.61      .4       0 4961.41     .06       0
 5037.51      .4       0    5108      .2       0
#XS Ineff= 2 , 0
       0 4951.41   165.1 5047.51       0  164.32
Permanent Ineff=
       F       F
Bank Sta=4961.41,5037.51
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,245265  ,,,
BEGIN DESCRIPTION:
PL1_K100-00-00-S99
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,2,2.6,0, 19, 19, , , .95, 0, ,,,
    4958 4961.41 4962.61 4964.32 4964.41 4973.11 4991.91 4992.41 4992.91 4993.51
 5006.61 5007.61 5009.31 5019.41  5032.3 5032.41 5037.51 5039.51    5045
  166.72  166.69  166.82  166.81  166.81  166.74  166.58  166.58  166.58  166.57
  166.47  166.46  166.44  166.36  166.26  166.26  166.22   166.2  166.14
  166.71  166.68  165.91   164.8  164.81  164.74  164.58  164.58  164.58  164.57
  164.47  164.46  164.44  164.36  164.26  163.96  165.93  166.01
    4958 4961.41 4962.61 4964.32 4964.41 4973.11 4991.91 4992.41 4992.91 4993.51
 5006.61 5007.61 5009.31 5019.41  5032.3 5032.41 5037.51 5039.51    5045
  166.72  166.69  166.82  166.81  166.81  166.74  166.58  166.58  166.58  166.57
  166.47  166.46  166.44  166.36  166.26  166.26  166.22   166.2  166.14
  166.71  166.68  165.91   164.8  164.81  164.74  164.58  164.58  164.58  164.57
  164.47  164.46  164.44  164.36  164.26  163.96  165.93  166.01
Pier Skew, UpSta & Num, DnSta & Num=  ,4986.6, 2 ,4986.6, 2 , 0 , 0 , 0 ,,
       1       1
  156.16  165.63
       1       1
  156.16  165.63
Pier Skew, UpSta & Num, DnSta & Num=  ,5012, 2 ,5012, 2 , 0 , 0 , 0 ,,
       1       1
  157.13  165.42
       1       1
  157.13  165.42
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=171.09

Type RM Length L Ch R = 1 ,245253  ,84.5,98,100.5
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
ROB spills into U101-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
      2964149.21       13899177.       2964124.1     13895522.98
      2965136.95       13893224.      2965458.88     13893072.97
      2969071.34     13889777.43
#Sta/Elev= 30
 -1345.1  169.08  1994.9  165.75  2395.3  166.52  2415.3  165.42  2535.2  166.92
  2715.3  166.02  2995.3  167.42    4818  165.12 4873.71  165.74 4884.61  167.35
  4927.9  166.98 4961.41   166.7 4973.11  159.15 4992.41  156.44 4993.51  153.88
 5006.61  155.84 5009.31  157.92 5019.41  158.97 5037.51  165.95 5071.41  167.37
 5096.11  165.23    7278  165.02    7328  165.82    7688  165.52    7698  164.72
    8098  165.32    8128  164.32    8198  165.42    8238  164.42 10064.6  166.52
#Mann= 5 ,-1 , 0
 -1345.1      .2       0  4927.9      .4       0 4961.41     .06       0
 5037.51      .4       0 5071.41      .2       0
#XS Ineff= 2 , 0
       0 4954.74   165.1 5044.18       0  164.32
Permanent Ineff=
       F       F
Bank Sta=4961.41,5037.51
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,245155. ,479,558,317.7
BEGIN DESCRIPTION:
K100-00-00-S99_PIPELINE -DS - XS1
ROB spills into U101-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
       2964234.9      13899159.8      2964208.92     13895539.74
      2965193.21     13893305.57      2965515.14     13893154.54
       2969127.6     13889859.01
#Sta/Elev= 30
 -1232.6  169.22  1987.4   165.3  2513.9  166.31  2533.9  164.56  2593.9  166.77
  2983.9  167.42  3043.9  166.26  3263.9  167.24  3493.9  165.84  4053.9  166.51
  4829.1  165.05  4879.1  166.06  4959.1  165.81 4964.51  164.47 4973.56  159.23
 4993.63  156.31 4994.78  154.11 5007.46  156.13 5010.08  158.04  5069.1  168.63
  5089.1   169.3  5129.1  166.66  5149.1  165.41  7484.7  165.69  8104.7  165.31
  8214.7  164.14  8254.7  165.59  8324.7  164.34  8384.7  165.39 10074.5  166.25
#Mann= 5 ,-1 , 0
 -1232.6      .2       0  4879.1      .4       0  4959.1     .06       0
  5069.1      .4       0  5129.1      .2       0
Bank Sta=4959.1,5069.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,244597  ,953.5,1027,997.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X98
ROB spills into U101-00-00. LOB spills to K172.
END DESCRIPTION:
XS GIS Cut Line= 5
      2964611.95       13899117.      2964737.42     13895516.43
      2965566.47     13893818.48      2965863.22     13893459.42
      2969112.55     13890112.86
#Sta/Elev= 30
  -714.9  168.59  1045.1  165.88  2887.9  165.85  3279.1   167.1  3409.1   166.7
  3429.1   165.9  3659.1   166.9  3729.1   165.9  4864.3  165.21  4902.7  166.79
  4917.3  170.74  4961.3  164.14  4971.7  160.47  4992.4  156.38    5002  155.42
    5009  156.39    5031  165.66  5036.7  166.51    5139  165.02  7123.2   164.9
  7193.2   165.7  8063.2   164.7  8093.2   165.5  8153.2   164.4  8233.2   165.1
  8243.2   164.9  8263.2   162.7  8303.2   164.2  8453.2   165.1  9907.7   165.7
#Mann= 5 ,-1 , 0
  -714.9      .2       0  4917.3      .4       0  4961.3     .06       0
  5036.7      .4       0    5139      .2       0
Bank Sta=4961.3,5036.7
XS Rating Curve= 0
Exp/Cntr=.3,.1
