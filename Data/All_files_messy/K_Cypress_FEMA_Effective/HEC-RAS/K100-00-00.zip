HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 3 ,109413  ,,,
BEGIN DESCRIPTION:
BURLINGTON NORTHERN RR
Structure ID: K100-00-00-S15
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,10,2.6,0, 26, 26, , , .95, 0, ,,,
    1837    1877  1887.1  3417.1  4572.1 4729.31  4729.4  4976.7  5049.2 5109.69
  5109.8    5272  5553.9  5893.5  5913.5  5973.5  7223.9  7333.5  7533.5  7583.5
  7773.5  7793.5  7973.5  7983.5  8013.5  8023.5
   126.5   127.1   130.2     125  122.03   121.8   121.8  121.56  121.57   121.4
   121.4  121.17   121.3  121.59  122.11  121.65   122.7  123.08  125.31  124.31
  125.21  125.11  126.41   126.1     126   125.6
                                                   119.7  119.46  119.47   119.3
                                                                                
                                                
    1837    1877  1887.1  3417.1  4572.1 4729.31  4729.4  4976.7  5049.2 5109.69
  5109.8    5272  5553.9  5893.5  5913.5  5973.5  7223.9  7333.5  7533.5  7583.5
  7773.5  7793.5  7973.5  7983.5  8013.5  8023.5
   126.5   127.1   130.2     125  122.03   121.8   121.8  121.56  121.57   121.4
   121.4  121.17   121.3  121.59  122.11  121.65   122.7  123.08  125.31  124.31
  125.21  125.11  126.41   126.1     126   125.6
                                                   119.7  119.46  119.47   119.3
                                                                                
                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4743.1, 2 ,4743.1, 2 , 0 , 0 , 0 ,,
     1.2     1.2
  113.83   120.7
     1.2     1.2
  113.33   120.2
Pier Skew, UpSta & Num, DnSta & Num=  ,4757, 2 ,4757, 2 , 0 , 0 , 0 ,,
     1.2     1.2
  108.01  120.69
     1.2     1.2
  107.51  120.19
Pier Skew, UpSta & Num, DnSta & Num=  ,4770.4, 2 ,4770.4, 2 , 0 , 0 , 0 ,,
     1.2     1.2
  102.35  120.69
     1.2     1.2
  101.85  120.19
Pier Skew, UpSta & Num, DnSta & Num=  ,4783.5, 2 ,4783.5, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   99.38  120.68
     1.2     1.2
   98.88  120.18
Pier Skew, UpSta & Num, DnSta & Num=  ,4797.4, 2 ,4797.4, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   99.95  120.67
     1.2     1.2
   99.45  120.17
Pier Skew, UpSta & Num, DnSta & Num=  ,4811.2, 2 ,4811.2, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   102.3  120.65
     1.2     1.2
   101.8  120.15
Pier Skew, UpSta & Num, DnSta & Num=  ,4825.2, 2 ,4825.2, 2 , 0 , 0 , 0 ,,
     1.2     1.2
  101.45  120.63
     1.2     1.2
  100.95  120.13
Pier Skew, UpSta & Num, DnSta & Num=  ,4838.7, 2 ,4838.7, 2 , 0 , 0 , 0 ,,
     1.2     1.2
  101.09  120.61
     1.2     1.2
  100.59  120.11
Pier Skew, UpSta & Num, DnSta & Num=  ,4852.7, 2 ,4852.7, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   99.59   120.6
     1.2     1.2
   99.09   120.1
Pier Skew, UpSta & Num, DnSta & Num=  ,4866.1, 2 ,4866.1, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   97.38  120.58
     1.2     1.2
   96.88  120.08
Pier Skew, UpSta & Num, DnSta & Num=  ,4880.3, 2 ,4880.3, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   94.51  120.57
     1.2     1.2
   94.01  120.07
Pier Skew, UpSta & Num, DnSta & Num=  ,4893.8, 2 ,4893.8, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   93.94  120.56
     1.2     1.2
   93.44  120.06
Pier Skew, UpSta & Num, DnSta & Num=  ,4907.3, 2 ,4907.3, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   96.63  120.55
     1.2     1.2
   96.13  120.05
Pier Skew, UpSta & Num, DnSta & Num=  ,4920.9, 2 ,4920.9, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   97.19  120.54
     1.2     1.2
   96.69  120.04
Pier Skew, UpSta & Num, DnSta & Num=  ,4935.1, 2 ,4935.1, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   94.14  120.53
     1.2     1.2
   93.64  120.03
Pier Skew, UpSta & Num, DnSta & Num=  ,4948.7, 2 ,4948.7, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   92.02  120.51
     1.2     1.2
   91.52  120.01
Pier Skew, UpSta & Num, DnSta & Num=  ,4962.3, 2 ,4962.3, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   91.11  120.48
     1.2     1.2
   90.61  119.98
Pier Skew, UpSta & Num, DnSta & Num=  ,4977, 2 ,4977, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   88.95  120.46
     1.2     1.2
   88.45  119.96
Pier Skew, UpSta & Num, DnSta & Num=  ,4989.8, 2 ,4989.8, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   88.59  120.46
     1.2     1.2
   88.09  119.96
Pier Skew, UpSta & Num, DnSta & Num=  ,5003, 2 ,5003, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   87.76  120.46
     1.2     1.2
   87.26  119.96
Pier Skew, UpSta & Num, DnSta & Num=  ,5017.3, 2 ,5017.3, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   88.83  120.47
     1.2     1.2
   88.33  119.97
Pier Skew, UpSta & Num, DnSta & Num=  ,5030.5, 2 ,5030.5, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   87.52  120.47
     1.2     1.2
   87.02  119.97
Pier Skew, UpSta & Num, DnSta & Num=  ,5044.4, 2 ,5044.4, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   93.72  120.47
     1.2     1.2
   93.22  119.97
Pier Skew, UpSta & Num, DnSta & Num=  ,5057, 2 ,5057, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   101.5  120.45
     1.2     1.2
     101  119.95
Pier Skew, UpSta & Num, DnSta & Num=  ,5070.3, 2 ,5070.3, 2 , 0 , 0 , 0 ,,
     1.2     1.2
  105.65  120.41
     1.2     1.2
  105.15  119.91
Pier Skew, UpSta & Num, DnSta & Num=  ,5082.9, 2 ,5082.9, 2 , 0 , 0 , 0 ,,
     1.2     1.2
  110.52  120.38
     1.2     1.2
  110.02  119.88
Pier Skew, UpSta & Num, DnSta & Num=  ,5097.5, 2 ,5097.5, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   115.2  120.33
     1.2     1.2
   114.7  119.83
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=128.11

Type RM Length L Ch R = 1 ,109400  ,118.8,100,105.7
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 2
      3057897.65     13927334.31      3060773.37     13921856.75
#Sta/Elev= 30
    1837     126    3017   123.6    3587   113.7    3687   116.6    3717   112.6
    3857   110.3    4217   111.3    4297   106.9    4757  108.77  4788.2   99.03
  4813.1  103.12  4893.5   94.43  4927.6    99.8  4948.7   92.56    5006   87.46
  5030.5   87.95    5057  102.38  5423.5   100.3  5443.5   104.9  5503.5   103.5
  5543.5   107.5  5803.5     109  5873.5   120.9  5913.5   121.6  6033.5   114.2
  6743.5   107.8  7223.5   113.3  7333.5   121.3  7533.5   124.8  8023.5   125.1
#Mann= 4 ,-1 , 0
    1837     .14       0    4757     .06       0    5057     .14       0
  5913.5      .1       0
#XS Ineff= 2 , 0
       0 4726.56  121.01 5132.81       0   120.9
Permanent Ineff=
       F       F
Bank Sta=4757,5057
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,109300. ,488.5,382,80.7
BEGIN DESCRIPTION:
K100-00-00-S15_BNRR -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 3
      3057990.79     13927371.86      3059617.82     13924272.75
      3060822.66     13921874.16
#Sta/Elev= 30
  1858.6  128.41  2468.6  128.63  3228.6  120.74  3648.6  124.33  3878.6  113.67
  4218.6   109.8  4488.6  112.61  4798.6  106.68  4888.6  110.94  4928.6  107.22
  4958.6   98.99 4965.72   91.67 5001.33   87.41 5021.04   91.27  5058.6  108.38
  5078.6   110.7  5798.9  110.24  5868.9  120.05  5918.9  121.75  5948.9  121.62
  5988.9  113.73  6028.9  112.16  6148.9   115.1  6638.9  113.13  6758.9  110.31
  6788.9  106.49  6838.9  111.99  7008.9  115.89  7668.9  125.84    8043  125.76
#Mann= 3 ,-1 , 0
  1858.6     .14       0  4888.6     .06       0  5078.6     .12       0
#XS Ineff= 2 , 0
       0    4626     1215183.057       0     121
Permanent Ineff=
       F       F
Bank Sta=4888.6,5078.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,108918  ,941.5,417,112.7
BEGIN DESCRIPTION:
Cross Section XS33.5
END DESCRIPTION:
XS GIS Cut Line= 5
      3058407.11      13927608.6      3059846.63     13924701.93
      3059796.13     13924547.44      3059696.85     13924288.93
      3060880.19     13921849.68
#Sta/Elev= 30
  1664.3   128.9  2464.3     128  3254.3   125.3  3304.3   122.7  3604.3   125.3
  4134.3   118.7  4304.3   112.9  4474.3     117  4664.3   108.1  4734.3   108.1
  4844.3   115.8  4927.9   109.2  4983.5   87.22  5022.1   90.13  5043.7   99.74
  5120.4   108.4  5320.4   113.2  5757.4   111.1  5787.4   112.9  5817.4   120.6
  5857.4   121.4  5907.4   120.3  5987.4   112.9  6187.4   115.5  6647.4   112.1
  6717.4   108.4  6737.4   103.7  6857.4   114.6  7567.4   125.1  8058.5   128.3
#Mann= 5 ,-1 , 0
  1664.3      .1       0  2464.3     .12       0  4844.3     .06       0
  5320.4     .14       0  5857.4      .1       0
#XS Ineff= 2 , 0
                            5375          121.12
Permanent Ineff=
       F       F
Bank Sta=4844.3,5320.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,108501. ,232.9,227,86.1
BEGIN DESCRIPTION:
K100-00-00-S14_CYPRESSWOOD -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 6
      3060816.39      13928179.3      3060789.04     13924928.78
      3060227.99      13924522.5      3060155.07     13924339.45
      3059915.47     13924123.66      3060922.89     13921840.02
#Sta/Elev= 30
   970.2  127.11  2130.2  127.51  2750.2  124.33  2960.2  119.37  3180.2   120.7
  3250.2  116.27  3340.2  119.01  3540.2  114.08  3590.2  116.96  3760.2  110.13
  3920.2  113.28  3980.2  109.22  4110.2  116.67  4260.9  107.21  4450.9  107.32
  4480.9  103.18  4510.9   92.42  4530.9   93.09  4600.9   110.5  4860.9  111.17
 4957.56   99.28  4983.5   87.01 5037.54   93.87  5083.6  108.57  5553.1  109.95
  5583.1  111.45  5623.1  120.83  6763.1  112.96  7003.1   118.4  7929.1   127.8
#Mann= 6 ,-1 , 0
   970.2     .99       0  3340.2      .1       0  3590.2     .07       0
  4860.9     .06       0  5083.6     .06       0  7003.1     .12       0
#XS Ineff= 2 , 0
                         5629.63          120.95
Permanent Ineff=
       F       F
Bank Sta=4860.9,5083.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,108274  ,90.5,86,47.1
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 6
      3060979.88     13928173.43      3060940.75     13924769.52
      3060569.06     13924495.64      3060288.26     13924246.63
      3060050.65     13924035.92      3060950.53     13921874.24
#Sta/Elev= 30
   905.7   128.6  1245.7   125.3  1865.7   127.9  2745.7   124.8  3501.5  115.07
  3575.7   120.5  3695.7   111.1  3795.7   110.5  4115.7   116.8  4175.7   112.3
  4265.7   116.8  4379.8     109  4596.9  107.13  4627.3  103.37  4678.2   89.29
  4699.2   96.86  4758.1  102.72  4915.6  107.86    4950   102.8  4983.5    86.9
  5022.1   89.81  5043.7   99.42  5141.3  108.87  5166.8   112.6  5464.4     112
  5504.4   120.4  6084.4   114.4  6794.4   115.8  7414.4   126.1  7805.9   128.4
#Mann= 4 ,-1 , 0
   905.7     .99       0  3501.5     .06       0  4596.9     .06       0
  5141.3      .1       0
#XS Ineff= 2 , 0
       0    4575  116.28    5173       0  120.42
Permanent Ineff=
       F       F
Bank Sta=4596.9,5141.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,108232  ,,,
BEGIN DESCRIPTION:
CYPRESSWOOD DRIVE - PIERS #2 AND #5 NOT TIED
Structure ID: K100-00-00-S14
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,64,2.6,0, 60, 60, , , .95, 0, ,,,
   905.7  1155.7  1245.7  1345.7  1505.7  1545.7  1575.7  1615.7  1655.7  1695.7
  1745.7  1865.7  2265.7  2305.7  2355.7  2615.7  2645.7  2745.7  2855.7  2915.7
  2945.7  3155.7  3205.7  3335.7  3485.7  3525.7  3575.7  3615.7  3695.7  3795.7
  3845.7  3945.7  4095.7  4115.7  4175.7  4265.7  4295.7  4308.3 4360.89    4361
 4584.41 4584.49  4931.8 5162.99 5163.11  5163.2  5382.3 5382.41  5614.4  5734.4
  5894.4  6084.4  6104.4  6794.4  7124.4  7334.4  7414.4  7564.4  7614.4  7805.9
   128.6     128   125.3   127.9   127.7   125.4   125.2   126.7   126.4   124.8
   126.8   127.9   126.3   124.5   126.3   123.3   124.6   124.8   122.8   120.2
   121.3   119.6   116.6   118.3   114.6   115.8   120.5     116   111.1   110.5
     113   114.7   114.7   116.8   112.3   116.8   114.4   116.3  117.35  120.15
  121.58  121.58  123.25  122.59  122.59  122.59  123.09  120.29   120.4   118.7
   118.6   114.4   115.5   115.8   122.2   123.8   126.1   125.6   127.8   128.4
                                                                                
                                                                                
                                                                                
                                                                                
          115.28  116.95  116.29  111.64
                                                                                
   905.7  1155.7  1245.7  1345.7  1505.7  1545.7  1575.7  1615.7  1655.7  1695.7
  1745.7  1865.7  2265.7  2305.7  2355.7  2615.7  2645.7  2745.7  2855.7  2915.7
  2945.7  3155.7  3205.7  3335.7  3485.7  3525.7  3575.7  3615.7  3695.7  3795.7
  3845.7  3945.7  4095.7  4115.7  4175.7  4265.7  4295.7  4308.3 4360.89    4361
 4584.41 4584.49  4931.8 5162.99 5163.11  5163.2  5382.3 5382.41  5614.4  5734.4
  5894.4  6084.4  6104.4  6794.4  7124.4  7334.4  7414.4  7564.4  7614.4  7805.9
   128.6     128   125.3   127.9   127.7   125.4   125.2   126.7   126.4   124.8
   126.8   127.9   126.3   124.5   126.3   123.3   124.6   124.8   122.8   120.2
   121.3   119.6   116.6   118.3   114.6   115.8   120.5     116   111.1   110.5
     113   114.7   114.7   116.8   112.3   116.8   114.4   116.3  117.35  120.15
  121.58  121.58  123.25  122.59  122.59  122.59  123.09  120.29   120.4   118.7
   118.6   114.4   115.5   115.8   122.2   123.8   126.1   125.6   127.8   128.4
                                                                                
                                                                                
                                                                                
                                                                                
          115.28  116.95  116.29  111.64
                                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4627.3, 2 ,4627.3, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  102.09  116.63
     1.5     1.5
  104.05  118.59
Pier Skew, UpSta & Num, DnSta & Num=  ,4758.1, 2 ,4758.1, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  101.61  117.54
     1.5     1.5
  103.57   119.5
Pier Skew, UpSta & Num, DnSta & Num=  ,4816.4, 2 ,4816.4, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  103.69  117.69
     1.5     1.5
  105.65  119.65
Pier Skew, UpSta & Num, DnSta & Num=  ,4875.5, 2 ,4875.5, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   105.7  117.82
     1.5     1.5
  107.66  119.78
Pier Skew, UpSta & Num, DnSta & Num=  ,4933.8, 2 ,4933.8, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  104.03  117.95
     1.5     1.5
  105.99  119.91
Pier Skew, UpSta & Num, DnSta & Num=  ,4992.2, 2 ,4992.2, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   86.11  117.86
     1.5     1.5
   88.07  119.82
Pier Skew, UpSta & Num, DnSta & Num=  ,5051, 2 ,5051, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   98.76  117.67
     1.5     1.5
  100.72  119.63
Pier Skew, UpSta & Num, DnSta & Num=  ,5108.3, 2 ,5108.3, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  104.49  117.48
     1.5     1.5
  106.45  119.44
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=128.6

Type RM Length L Ch R = 1 ,108188  ,214.3,214,39.2
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
      3061040.44     13928121.42       3061001.2     13924707.55
      3060622.22      13924428.3      3060115.16     13923978.65
      3061009.56     13921830.15
#Sta/Elev= 30
   905.7  130.55  1245.7  127.25  1865.7  129.85  2745.7  126.75  3501.5  117.02
  3575.7  122.45  3695.7  113.05  3795.7  112.45  4115.7  118.75  4175.7  114.25
  4265.7  118.75  4379.8  110.95  4596.9  109.08  4627.3  105.32  4678.2   91.24
  4699.2   98.81  4758.1  104.67  4915.6  109.81    4950  104.75  4983.5   88.85
  5022.1   91.76  5043.7  101.37  5141.3  110.82  5166.8  114.55  5464.4  113.95
  5504.4  122.35  6084.4  116.35  6794.4  117.75  7414.4  128.05  7805.9  130.35
#Mann= 4 ,-1 , 0
   905.7     .99       0  3501.5     .06       0  4596.9     .06       0
  5141.3      .1       0
#XS Ineff= 2 , 0
       0    4575  116.28 5164.06       0  120.85
Permanent Ineff=
       F       F
Bank Sta=4596.9,5141.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,107974. ,371,332,28.6
BEGIN DESCRIPTION:
K100-00-00-S14_CYPRESSWOOD -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3061131.78      13928125.7      3061089.13     13924529.25
      3060224.43     13923816.65      3060992.31     13921921.07
#Sta/Elev= 30
   724.7  127.89   774.7  125.19   864.7  128.06  2224.7  126.32  2964.7  117.04
  3074.7  119.57  3244.7  115.05  3524.7  117.17  3564.7     114  4114.7  115.67
  4314.7   108.5  4451.5  111.24  4511.5  105.84  4751.5  112.95  4811.5  107.84
  4861.5   94.07  4941.5  102.54  4971.5   97.04 4992.51   88.58  5071.5   106.2
  5101.5  106.74  5141.5  114.34  5271.5  113.97  5331.5   119.8    5862  116.59
    5962  108.98    6182   109.2    6412  118.25    6632   117.7  7487.2     128
#Mann= 5 ,-1 , 0
   724.7     .99       0  3564.7     .07       0  4811.5     .06       0
  5071.5     .06       0    6632      .1       0
#XS Ineff= 2 , 0
                         5358.55          120.95
Permanent Ineff=
       F       F
Bank Sta=4811.5,5071.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,107642  ,711.1,1010,672.7
BEGIN DESCRIPTION:
Cross Section XS33.1
END DESCRIPTION:
XS GIS Cut Line= 6
        3061529.       13926964.      3061518.93     13924385.11
      3060738.67     13923821.96      3060648.89     13923757.12
       3060358.5     13923551.92      3060999.56     13921952.05
#Sta/Elev= 30
  1417.5   125.7  1837.5   125.4  2387.5   117.1  3117.5   118.2  3397.5     112
  3557.5   118.7  3727.5   113.3  4096.5   113.7  4196.5   104.9  4336.5   110.4
  4426.5   105.6  4466.5   110.8  4516.5   103.7  4796.5   103.3  4866.5   108.8
  4949.7  106.02  4979.3   91.02  5006.5   88.17  5038.7   101.5  5109.5   114.9
  5189.5   113.2  5259.5   119.7  5535.1   116.9  5595.1   112.9  5655.1   101.4
  5845.1   109.5  6035.1   109.9  6175.1     119  6255.1   118.2  7148.6     128
#Mann= 5 ,-1 , 0
  1417.5     .99       0  3557.5     .07       0  4866.5     .06       0
  5109.5     .06       0  6255.1      .1       0
#XS Ineff= 2 , 0
                         5251.95          120.45
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
 5436.52 6202.15  117.42
Bank Sta=4866.5,5109.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,106632  ,746.5,1842,2044.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X33A
END DESCRIPTION:
XS GIS Cut Line= 6
      3061820.63     13926812.28      3061830.41     13923799.63
      3061320.74     13923056.96      3061214.71     13922902.46
      3061145.72     13922801.93      3061018.56      13921872.7
#Sta/Elev= 30
   984.4   124.7  1614.4   117.9  1834.4   121.1  2554.4   119.6  2694.4   113.1
  2834.4   117.4  2984.4   111.3  3134.4   114.5  3334.4   112.5  3384.4   119.9
  3514.4   112.4  3654.4   116.2  3934.4   113.4  3964.4   116.8  3997.1   111.7
  4087.1   108.9  4287.1   107.2  4407.1   113.1  4527.1   103.9  4903.1  109.45
  4926.8  104.45  4949.7   104.8  4968.7   96.81  4981.7   89.05  5006.5   86.95
    5019   89.43  5019.9   98.95  5066.5  101.64  5093.8  113.51    6145     128
#Mann= 6 ,-1 , 0
   984.4     .99       0  2834.4     .07       0  4903.1     .07       0
  4968.7     .06       0  5019.9      .1       0  5093.8      .1       0
Bank Sta=4903.1,5093.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,104790  ,1075.8,1359,1178.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X33
END DESCRIPTION:
XS GIS Cut Line= 4
      3061879.32     13926851.41       3062622.7     13923388.81
      3063013.96     13923066.03      3063825.81     13921745.55
#Sta/Elev= 30
  1183.7   124.3  1543.7   122.9  1713.7   118.3  1963.7   122.8  2373.7   117.5
  2663.7     120  2803.7   114.2  3013.7   114.7  3073.7   119.2  3183.7   111.7
  3373.7   111.9  3443.7   116.5  3743.7   113.6  3933.7   106.4  4273.7   110.2
  4735.2   103.8  4825.8  106.21  4947.6  101.31  4965.9   98.31  4979.9   89.02
  4996.1    86.9  5023.6   90.43  5045.1   107.5  5562.4   118.9  5632.4     119
  5672.4   115.6  5942.4     121  6622.4   126.3  6712.4   122.5  6782.5   125.7
#Mann= 4 ,-1 , 0
  1183.7     .99       0  3073.7     .07       0  4947.6     .06       0
  5045.1      .1       0
Bank Sta=4947.6,5045.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,103431  ,358.1,401,289.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X32
END DESCRIPTION:
XS GIS Cut Line= 4
      3062016.26     13926900.32      3063444.33      13924445.2
       3063884.5      13923868.1      3064911.54     13922391.11
#Sta/Elev= 30
  1702.7   125.1  1802.7   121.9  1852.7   123.3  2122.7   120.9  2302.7   122.9
  2542.7   119.1  2652.7   121.2  3142.7   117.5  3222.7   118.9  3300.1  114.31
  4102.7   113.2  4432.7   105.4  4562.9   109.3  4692.9   102.6  4732.9   102.3
  4782.9   106.8  4956.7  103.65  4979.4   90.42  4981.1   87.22  4995.3    86.7
  5019.7   89.85  5029.1   96.36  5049.8  104.63  5268.7   112.7  5428.7   111.8
  5708.7   115.6  5828.7   120.2  6148.7   118.5  6578.7   123.5  7067.7   123.9
#Mann= 5 ,-1 , 0
  1702.7     .99       0  3300.1     .07       0  4956.7     .06       0
  5049.8     .12       0  5708.7      .1       0
#XS Ineff= 2 , 0
                         5826.17          120.34
Permanent Ineff=
       F       F
Bank Sta=4956.7,5049.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,103030  ,131.2,129,130.9
BEGIN DESCRIPTION:
Cross Section XS31.7
END DESCRIPTION:
XS GIS Cut Line= 4
      3062300.82      13926955.5      3064045.57     13924163.65
       3064123.8      13924037.8      3065140.58     13922471.26
#Sta/Elev= 30
  1620.8   122.9  1860.8     120  2690.8   120.1  2740.8   117.5  3070.8   119.9
  3160.8   114.4  3230.8   114.1  3430.8   116.7  3870.8   109.2  4120.8   108.4
  4310.8   114.2  4520.8   105.2  4600.8   105.2  4670.8   110.8  4790.8     106
  4880.8   109.3    4943     106    4953   105.1 5005.68   88.48 5028.68    89.5
 5045.52   97.45    5053   105.5  5071.2   109.1  5091.2     110  5471.2   115.1
  5551.2   118.9  5881.2   120.4  5991.2   118.2  6081.2     122  6928.8   123.2
#Mann= 6 ,-1 , 0
  1620.8     .99       0  3430.8     .07       0    4943     .06       0
  5071.2     .06       0  5091.2     .12       0  5551.2      .1       0
#XS Ineff= 2 , 0
                         5576.17          119.25
Permanent Ineff=
       F       F
Bank Sta=4943,5071.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,102901  ,26.5,26,26.7
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
       3062691.2     13926726.82      3064041.03     13924389.08
      3064324.68     13923968.48      3065214.79     13922618.66
#Sta/Elev= 30
  2047.1  122.56  2237.1  119.56  2387.2  120.76  3107.2  118.06  3217.1  113.36
  3337.1  114.86  3367.1  117.46  3427.2  118.56  3737.1  108.46  3837.2  113.06
  4007.2  111.26  4047.1  109.36  4107.2  110.26  4167.1  107.86  4437.2  107.76
  4637.1  103.26 4936.48   108.4 4950.78   102.2 4970.08   90.64 4971.68   89.37
 5005.68   89.05 5028.98   90.68  5066.6  107.35  5353.9  113.66    5374  113.46
    5394  110.86    5474  114.06  5503.9  113.56  5873.9  119.16  6870.9  122.76
#Mann= 7 ,-1 , 0
  2047.1     .99       0  3337.1     .07       0 4936.48     .07       0
 4970.08     .06       0 5028.98     .12       0  5066.6     .12       0
  5503.9      .1       0
#XS Ineff= 2 , 0
                         5857.42          119.43
Permanent Ineff=
       F       F
Bank Sta=4936.48,5066.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,102890.5,,,
BEGIN DESCRIPTION:
PL1_K100-00-00-S13
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,1,2.6,0, 22, 22, , , .95, 0, ,,,
 4904.22 4904.33 4904.42 4914.02 4936.48 4950.78 4960.18 4970.08 4971.18 4971.68
 5000.18 5000.82 5005.68 5028.68 5028.78 5028.98 5039.08 5041.88 5045.52 5055.91
 5056.02    5058
  108.16  108.27  108.35  117.55  117.61  117.65  117.67   117.7   117.7   117.7
  117.78  117.78  117.77  117.73  117.73  117.73  117.71  117.71   117.7  107.05
  106.94   103.6
                  107.87  116.55  116.61  116.65  116.67   116.7   116.7   116.7
  116.78  116.78  116.77  116.73  116.73  116.73  116.71  116.71   116.7  106.05
  105.94   102.6
 4904.22 4904.33 4904.42 4914.02 4936.48 4950.78 4960.18 4970.08 4971.18 4971.68
 5000.18 5000.82 5005.68 5028.68 5028.78 5028.98 5039.08 5041.88 5045.52 5055.91
 5056.02    5058
  108.16  108.27  108.35  117.55  117.61  117.65  117.67   117.7   117.7   117.7
  117.78  117.78  117.77  117.73  117.73  117.73  117.71  117.71   117.7  107.05
  106.94   103.6
                  107.87  116.55  116.61  116.65  116.67   116.7   116.7   116.7
  116.78  116.78  116.77  116.73  116.73  116.73  116.71  116.71   116.7  106.05
  105.94   102.6
Pier Skew, UpSta & Num, DnSta & Num=  ,4919.9, 2 ,4919.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  107.13  117.57
     1.5     1.5
  107.13  117.57
Pier Skew, UpSta & Num, DnSta & Num=  ,4960.9, 2 ,4960.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   94.33  117.67
     1.5     1.5
   94.33  117.67
Pier Skew, UpSta & Num, DnSta & Num=  ,4999.8, 2 ,4999.8, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   88.64  117.78
     1.5     1.5
   88.64  117.78
Pier Skew, UpSta & Num, DnSta & Num=  ,5039.8, 2 ,5039.8, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   94.37  117.71
     1.5     1.5
   94.37  117.71
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=122.76

Type RM Length L Ch R = 1 ,102875  ,111.7,113,112.1
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3062713.61     13926741.07      3064063.09     13924403.93
      3064346.41     13923983.82      3065236.57     13922633.91
#Sta/Elev= 30
  2047.1  122.58  2237.1  119.58  2387.2  120.78  3107.2  118.08  3217.1  113.38
  3337.1  114.88  3367.1  117.48  3427.2  118.58  3737.1  108.48  3837.2  113.08
  4047.1  109.38  4107.2  110.28  4167.1  107.88  4437.2  107.78  4637.1  103.28
 4936.48  108.42 4950.78  102.22 4971.68   89.39 5005.68   89.07 5028.68   90.09
  5066.6  107.37  5353.9  113.68    5374  113.48    5394  110.88    5474  114.08
    5514  113.08  5563.9  115.58    5624  115.08  5873.9  119.18  6870.9  122.78
#Mann= 4 ,-1 , 0
  2047.1     .99       0  3337.1     .07       0 4936.48     .06       0
  5066.6      .1       0
#XS Ineff= 2 , 0
                         5847.66          119.43
Permanent Ineff=
       F       F
Bank Sta=4936.48,5066.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,102762. ,91.2,95,81.7
BEGIN DESCRIPTION:
K100-00-00-S13A_PIPELINE -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3062805.73      13926804.6      3064155.21     13924467.54
      3064438.54     13924047.43      3065278.49     13922693.08
#Sta/Elev= 30
  2060.7  122.14  2260.7  118.83  2880.7  119.87  3140.7  116.96  3230.7  112.43
  3310.7  112.64  3370.7  117.17  3860.7  109.17  4110.7  115.57  4190.7  111.32
  4400.7  108.88  4590.7  111.47  4660.7  100.33  4899.5  109.19    4932  106.07
 4971.85   93.51 4977.68   89.19 5005.68   88.81 5027.28   89.77 5060.12  104.25
  5069.5  111.32  5219.5  109.16  5306.2  116.07  5516.2   114.8  5886.2  121.44
  6386.2  119.91  6476.2  123.04  6526.2  120.04  6856.2  122.56  6859.8  122.51
#Mann= 5 ,-1 , 0
  2060.7     .99       0  3370.7     .07       0  4899.5     .06       0
  5069.5     .07       0  6856.2      .1       0
Bank Sta=4899.5,5069.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,102667  ,1033.7,880,538.9
BEGIN DESCRIPTION:
Cross Section XS31.2
END DESCRIPTION:
XS GIS Cut Line= 4
      3062857.63       13926825.      3064312.79     13924395.75
       3064384.8     13924298.02      3065328.95      13922708.1
#Sta/Elev= 30
  2092.9   122.2  2412.9   117.8  3102.9   116.7  3152.9     119  3272.9   112.2
  3452.9   116.4  3612.9   112.3  3692.9   115.3  3732.9   110.2  3922.9   108.4
  4112.9   112.1  4392.9   108.1  4472.9   110.6  4622.9   108.2  4682.9   100.7
  4722.9    99.9  4772.9   104.4  4862.9   105.7  4892.9   110.7  4944.6   105.6
  4964.6    96.9 4971.68   88.92 5005.68    88.6 5028.68   89.62    5076   110.1
    5186   108.4    5756   119.8    6506   124.3    6636   121.1  6895.2     122
#Mann= 5 ,-1 , 0
  2092.9     .99       0  3152.9      .1       0  3272.9     .07       0
  4892.9     .06       0    5076     .07       0
Bank Sta=4892.9,5076
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,101787  ,444.5,841,1055.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X31
END DESCRIPTION:
XS GIS Cut Line= 6
      3063571.49     13927203.54      3064980.01     13925325.52
      3064980.01     13924875.58      3064980.01     13924631.04
      3064980.01     13923574.66      3065390.82     13922772.59
#Sta/Elev= 30
  2096.1   120.7  2616.1   118.1  2766.1   113.8  3006.1   113.8  3256.1   111.3
  3366.1     114  3526.1   109.6  3716.1   115.5  3796.1   111.3  3956.1     115
  4076.1   111.6  4156.1   112.6  4206.1     108  4336.1   105.6  4436.1   114.5
  4753.6     104  4933.9  111.44    4974   91.14  4974.1   88.54  5015.5   86.68
    5026   90.97    5049  107.64    5174  112.86  5178.1   110.2  5518.1   111.5
  6118.1   121.9  6664.5   120.1  6744.5   123.9  6804.5   121.7  7095.6   122.5
#Mann= 4 ,-1 , 0
  2096.1     .99       0  3006.1     .07       0  4933.9     .06       0
    5049     .07       0
#XS Ineff= 2 , 0
       0  4933.9  111.44               0
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
 4155.66  4424.4   112.5    4425    4426     100
Bank Sta=4933.9,5049
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,100946  ,473.3,1358,1194.8
BEGIN DESCRIPTION:
Cross Section XS30.9
END DESCRIPTION:
XS GIS Cut Line= 4
      3063935.24       13927396.      3065463.86      13925433.7
      3065501.75     13925361.52      3066969.29     13923428.08
#Sta/Elev= 30
  2459.6   120.8  2949.6   113.9  3379.6   115.8  3489.6   110.7  3579.6   112.1
  3739.6   108.9  3809.6   113.5  3879.6   111.8  4089.6   108.3  4489.6   112.5
  4639.6   105.4  4789.6   111.5  4899.6   111.9  4939.6   107.4  4974.1   87.65
  5015.5   85.79    5026   90.08    5049  106.75  5098.6     114  5138.6   112.3
  5178.6   114.7  5328.6   105.8  5638.6   109.5  5748.6   107.2  6588.6   121.8
  6688.6   116.9  6908.6     119  7038.6   115.5  7268.6   115.6  7455.9   117.9
#Mann= 6 ,-1 , 0
  2459.6     .99       0  3489.6     .07       0  3879.6      .1       0
  4899.6     .06       0  5098.6     .07       0  6588.6     .99       0
Bank Sta=4899.6,5098.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,99588   ,857.1,643,415.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X30B
END DESCRIPTION:
XS GIS Cut Line= 4
       3064510.5     13927399.16      3065566.89      13926068.9
      3066300.49      13926068.9      3067405.78     13924670.17
#Sta/Elev= 30
  2966.3   119.9  3166.3   115.1  3406.3   114.5  3486.3     118  3596.3   111.7
  3836.3   111.7  4386.3   110.2    4665   101.8    4835   108.8  4957.3     103
  4958.4   89.35  4995.5   84.36  5020.4   87.18  5030.8   95.13  5116.2  102.64
  5146.3  110.91    5345   109.3  5398.6   106.3  5478.6   108.2  5528.6   113.1
  5878.6   111.7  6068.6   114.4  6158.6     112  6338.6   114.8  6418.6   113.1
  6758.6   117.5  6858.6   115.6  6968.6   119.8  7018.6   118.3  7181.3   120.2
#Mann= 6 ,-1 , 0
  2966.3     .99       0  3486.3     .12       0  3836.3     .07       0
  4957.3     .06       0  5146.3      .1       0  5528.6     .99       0
Bank Sta=4957.3,5146.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,98945   ,281.9,205,128.9
BEGIN DESCRIPTION:
Cross Section XS30.7
END DESCRIPTION:
XS GIS Cut Line= 6
      3064451.21       13927528.      3065912.29     13926939.53
      3066315.07     13926549.98       3066372.7     13926494.56
      3066713.17     13926139.23      3067674.48     13924694.55
#Sta/Elev= 30
  2815.1   120.5  2975.1   119.6  3125.1   115.6  3515.1   119.2  3635.1   113.6
  4035.1   111.3  4105.1   113.8  4215.1   111.1  4440.2   111.8  4580.2     104
  4730.2   106.5  4800.2   104.2  4890.2   107.4  4945.4   98.65  4964.6   89.81
  4976.8   88.13  4981.4   84.55  4993.1   84.12    5022   86.73  5027.4   90.21
  5030.5    95.4  5040.5   101.2  5070.5   108.7  5310.5   110.3  5410.5   113.4
  5712.7   110.3  6162.7     115  6602.7   114.7  7212.7   118.5  7257.9   120.5
#Mann= 5 ,-1 , 0
  2815.1     .99       0  4105.1     .07       0  4890.2     .06       0
  5070.5      .1       0  6162.7     .99       0
Bank Sta=4890.2,5070.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,98740   ,109.2,106,107.7
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
      3064430.93     13927594.13      3066142.67     13927183.32
      3066437.72     13926744.24      3066573.05     13926527.97
      3067785.93     13924737.98
#Sta/Elev= 30
  2617.4   120.3  2787.4   117.6  2957.4   119.1  3067.4   116.4  3437.4     120
  3557.4   114.5  3787.4   113.8  3897.4   117.6  4027.4     113  4317.4   112.5
  4526.5  104.13    4857  103.85  4945.4   98.57  4964.6   89.73  4976.8   88.05
  4981.4   84.47  4993.1   84.04    5022   86.65  5027.4   90.13  5073.6  101.11
  5190.3  111.91  5701.9   109.6  6051.9   114.2  6161.9   112.8  6581.9   115.5
  6641.9   113.6  6681.9   116.2  7221.9   119.6  7251.9   118.1  7324.1   120.8
#Mann= 5 ,-1 , 0
  2617.4     .99       0  3897.4      .1       0    4857     .06       0
  5190.3      .1       0  6051.9     .99       0
#XS Ineff= 2 , 0
       0  4833.5  108.78  5158.3       0  110.76
Permanent Ineff=
       F       F
Bank Sta=4857,5190.3
XS Rating Curve= 0
Exp/Cntr=.5,.3
