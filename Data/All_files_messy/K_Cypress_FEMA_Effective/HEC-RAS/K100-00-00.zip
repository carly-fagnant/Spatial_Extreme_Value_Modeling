HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 3 ,41653.5 ,,,
BEGIN DESCRIPTION:
HARDY TOLL ROAD SB
Structure ID: K100-00-00-S7
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,65,2.6,0, 145, 145, , , .95, 0, ,,,
   533.6   553.6   583.6   643.6   653.6   663.6   683.6   743.6  2241.2  2393.6
  2423.6  2443.6  2473.6  2553.6  2643.6  2673.6  2683.6  2693.6  2723.6  2751.2
  2763.6  2773.6  2793.6  2853.6  2893.6  2923.6  2973.6  2993.6  3083.6  3123.6
  3193.6  3194.5  3223.6  3243.6  3253.6  3333.6  3393.6  3593.6  3623.6  3741.2
  3813.6  3823.6  3863.6  3986.8 3986.89    3987 3987.11  3994.3 4016.21 4016.33
  4016.4  4024.3  4074.3  4204.3  4214.3  4224.3  4244.3  4304.3  4311.8  4314.3
    4334  4418.1  4466.8  4520.7  4561.5  4584.7  4628.8  4629.4  4648.8  4649.4
  4676.2  4706.8  4748.7  4748.8  4749.2  4796.5    4849  4849.2  4849.3    4880
  4896.2  4913.9    4936  4947.2    4949  4949.1  4958.6  4977.3  4979.5  4996.8
  4999.3  4999.9  5019.9  5022.7  5040.3  5049.4  5049.6  5072.2  5094.7  5095.7
    5123  5125.7  5140.1  5148.9    5149  5149.8  5163.4    5190  5198.1  5222.5
  5247.6  5247.9  5248.7 5248.79  5248.9    5249  5254.3  5274.3  5307.8  5362.4
  5416.7 5443.59  5443.7 5443.81  5454.3  5473.8  5474.3  5534.3  5564.3  5584.3
  5604.3  5624.3  5634.3  5644.3  5674.3  5734.3  5763.8  5764.3  5974.3  5979.4
  6324.3  6354.3  6384.3  6404.3  6410.4
    96.1      96    95.4    95.9    95.7    94.8    95.5    95.7    94.4   93.74
   93.61   93.53    93.4   93.05   92.66   92.53   92.49   92.45   92.32    92.2
   92.19   92.19   92.31   92.15   92.51   92.11   92.09   92.08   92.03   92.01
   91.98   91.98   91.96   91.95   91.95   91.91   91.88   91.77   91.76    91.7
   91.79    91.8   91.85      92      92    95.1    95.1   95.12   95.19   95.19
   95.19   95.22   95.38    95.8   95.83   95.86   95.92   96.12   96.14   96.15
   96.21   96.48   96.49   96.69   96.99   97.23   97.69    97.7   97.99   97.99
   98.24   98.52   98.91   98.91   98.91   99.25   99.62   99.62   99.62   99.76
   99.84   99.89   99.95   99.98   99.99   99.99   99.99   99.98   99.98   99.97
   99.97   99.97   99.99   99.99     100  100.01  100.01   99.93   99.85   99.85
   99.69   99.68   99.59   99.54   99.54   99.54   99.48   99.38   99.35   99.11
   98.87   98.87   98.86   98.86   98.86   98.86   98.82   98.65   98.37   98.04
   97.63   97.63   97.63   94.53   94.52    94.5    94.5   94.42   94.38   94.35
   94.32   94.29   94.28   94.26   94.22   94.14    94.1    94.1   96.05    96.1
      98    97.7    98.1    97.8    97.9
                                                                                
                                                                                
                                                                                
                                                                                
                                                                           85.51
   85.51   85.52   85.68    86.1   86.13   86.16   86.22   86.42   86.42   86.42
   86.42   86.78   86.79   86.99   87.29   87.53   87.99      88   88.29   88.29
   88.54   88.82   89.21   89.21   89.21   89.55   89.92   89.92   89.92   90.06
   90.14   90.19   90.25   90.28   90.29   90.29   90.29   90.28   90.28   90.27
   90.27   90.27   90.29   90.29    90.3   90.31   90.31   90.23   90.15   90.15
   89.99   89.98   89.89   89.84   89.84   89.84   89.78   89.68   89.65   89.41
   89.17    89.7   89.36   89.32
                                                                                
                                                                                
                                        
   533.6   553.6   583.6   643.6   653.6   663.6   683.6   743.6  2241.2  2393.6
  2423.6  2443.6  2473.6  2553.6  2643.6  2673.6  2683.6  2693.6  2723.6  2751.2
  2763.6  2773.6  2793.6  2853.6  2893.6  2923.6  2973.6  2993.6  3083.6  3123.6
  3193.6  3194.5  3223.6  3243.6  3253.6  3333.6  3393.6  3593.6  3623.6  3741.2
  3813.6  3823.6  3863.6  3986.8 3986.89    3987 3987.11  3994.3 4016.21 4016.33
  4016.4  4024.3  4074.3  4204.3  4214.3  4224.3  4244.3  4304.3  4311.8  4314.3
    4334  4418.1  4466.8  4520.7  4561.5  4584.7  4628.8  4629.4  4648.8  4649.4
  4676.2  4706.8  4748.7  4748.8  4749.2  4796.5    4849  4849.2  4849.3    4880
  4896.2  4913.9    4936  4947.2    4949  4949.1  4958.6  4977.3  4979.5  4996.8
  4999.3  4999.9  5019.9  5022.7  5040.3  5049.4  5049.6  5072.2  5094.7  5095.7
    5123  5125.7  5140.1  5148.9    5149  5149.8  5163.4    5190  5198.1  5222.5
  5247.6  5247.9  5248.7 5248.79  5248.9    5249  5254.3  5274.3  5307.8  5362.4
  5416.7 5443.59  5443.7 5443.81  5454.3  5473.8  5474.3  5534.3  5564.3  5584.3
  5604.3  5624.3  5634.3  5644.3  5674.3  5734.3  5763.8  5764.3  5974.3  5979.4
  6324.3  6354.3  6384.3  6404.3  6410.4
    96.1      96    95.4    95.9    95.7    94.8    95.5    95.7    94.4   93.74
   93.61   93.53    93.4   93.05   92.66   92.53   92.49   92.45   92.32    92.2
   92.19   92.19   92.31   92.15   92.51   92.11   92.09   92.08   92.03   92.01
   91.98   91.98   91.96   91.95   91.95   91.91   91.88   91.77   91.76    91.7
   91.79    91.8   91.85      92      92    95.1    95.1   95.12   95.19   95.19
   95.19   95.22   95.38    95.8   95.83   95.86   95.92   96.12   96.14   96.15
   96.21   96.48   96.49   96.69   96.99   97.23   97.69    97.7   97.99   97.99
   98.24   98.52   98.91   98.91   98.91   99.25   99.62   99.62   99.62   99.76
   99.84   99.89   99.95   99.98   99.99   99.99   99.99   99.98   99.98   99.97
   99.97   99.97   99.99   99.99     100  100.01  100.01   99.93   99.85   99.85
   99.69   99.68   99.59   99.54   99.54   99.54   99.48   99.38   99.35   99.11
   98.87   98.87   98.86   98.86   98.86   98.86   98.82   98.65   98.37   98.04
   97.63   97.63   97.63   94.53   94.52    94.5    94.5   94.42   94.38   94.35
   94.32   94.29   94.28   94.26   94.22   94.14    94.1    94.1   96.05    96.1
      98    97.7    98.1    97.8    97.9
                                                                                
                                                                                
                                                                                
                                                                                
                                                                           85.51
   85.51   85.52   85.68    86.1   86.13   86.16   86.22   86.42   86.42   86.42
   86.42   86.78   86.79   86.99   87.29   87.53   87.99      88   88.29   88.29
   88.54   88.82   89.21   89.21   89.21   89.55   89.92   89.92   89.92   90.06
   90.14   90.19   90.25   90.28   90.29   90.29   90.29   90.28   90.28   90.27
   90.27   90.27   90.29   90.29    90.3   90.31   90.31   90.23   90.15   90.15
   89.99   89.98   89.89   89.84   89.84   89.84   89.78   89.68   89.65   89.41
   89.17    89.7   89.36   89.32
                                                                                
                                                                                
                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4748.7, 2 ,4748.7, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   80.61   90.21
     1.7     1.7
   80.98   90.58
Pier Skew, UpSta & Num, DnSta & Num=  ,4849.2, 2 ,4849.2, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   80.19   90.92
     1.7     1.7
   80.56   91.29
Pier Skew, UpSta & Num, DnSta & Num=  ,4949.1, 2 ,4949.1, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   75.36   91.29
     1.7     1.7
   75.73   91.66
Pier Skew, UpSta & Num, DnSta & Num=  ,5049.4, 2 ,5049.4, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   67.86   91.31
     1.7     1.7
   68.23   91.68
Pier Skew, UpSta & Num, DnSta & Num=  ,5149, 2 ,5149, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   77.11   90.84
     1.7     1.7
   77.48   91.21
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=98.06

Type RM Length L Ch R = 1 ,41578   ,40.2,82,90.1
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
      3104633.43     13944247.06       3105509.1     13940897.96
       3105871.1      13938677.2
#Sta/Elev= 30
   530.6   96.08   741.3    97.4  1270.6   88.81  1780.6    89.9  1800.6    94.3
  2166.3    91.9  2190.6   95.56  2279.3    91.7  3820.6   92.74  4012.3   92.37
  4062.3   80.08  4102.3    76.4  4182.3   77.97  4202.3    82.9  4242.3   92.72
  4292.3   91.99  4582.3   93.73  4642.3    90.1  4682.3   80.97  4822.3   82.21
  4948.6   77.17  4980.9   59.74  5001.3   57.36  5021.3   59.36  5073.6   77.23
  5212.3   81.01  5282.3   90.81  5632.3   88.53  5992.3   95.85  6242.3   96.82
#Mann= 7 ,-1 , 0
   530.6     .99       0  3820.6     .06       0  4202.3    .055       0
  4292.3     .06       0  4948.6    .055       0  5073.6     .06       0
  5992.3     .99       0
#XS Ineff= 2 , 0
       0  4012.7   92.36    5256       0      92
Permanent Ineff=
       F       F
Bank Sta=4948.6,5073.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,41496   ,103,130,128.6
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3105034.23       13942973.      3105484.25     13941095.96
      3105643.21     13940357.71       3106051.6     13938672.65
#Sta/Elev= 30
    1872  106.66    2222   94.76    2342   92.86  3031.2   92.56  3992.2   93.16
  4022.2   91.66  4082.2   76.96  4102.2   76.46  4192.2   78.66  4222.2   88.96
  4252.2   93.06  4337.6   91.31  4631.7   93.98  4678.2   81.22  4848.3   80.87
  4874.4   79.18  4908.3   74.18  4926.1   69.19  4943.3   69.74  4969.9   60.09
  4996.7   57.88  5025.5   58.52  5048.1   69.87  5058.3   78.09  5208.1   77.98
  5487.4   86.86  5767.4   89.26  5915.4    94.1  6167.4   94.46  6291.2   97.46
#Mann= 7 ,-1 , 0
    1872     .99       0  3031.2     .06       0  3992.2    .055       0
  4252.2     .06       0  4874.4    .055       0  5058.3     .06       0
  5915.4     .99       0
#XS Ineff= 2 , 0
       0    4033    93.2  5255.8       0    97.1
Permanent Ineff=
       F       F
Bank Sta=4874.4,5058.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,41431   ,,,
BEGIN DESCRIPTION:
HARDY TOLL ROAD NB
Structure ID: K100-00-00-S6
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,110,2.6,0, 109, 115, , , .95, 0, ,,,
    1872    1882    1912    1932    1942    2222    2302    2342    2362    2392
  3031.2  3231.2  3802.2  3931.2  3989.8 3989.89    3990 3990.11  3992.2  4022.2
  4032.2 4034.81 4034.93    4035  4042.2  4062.2  4072.2  4082.2  4102.2  4132.2
  4142.2  4152.2  4172.2  4192.2  4202.2  4216.1  4216.2  4222.2  4242.2  4252.2
    4278 4278.09  4278.2 4278.31  4279.5  4337.6  4340.4  4393.4  4395.3  4445.2
  4446.4  4500.7  4502.3    4555  4558.8  4615.9  4617.2  4631.7  4648.5  4650.1
  4650.2  4678.2  4697.2  4747.3  4748.2  4800.7  4800.9  4848.2  4848.3  4874.4
  4908.3  4926.1  4943.3  4948.6  4969.9  4973.2  4996.7  5025.5  5030.1  5037.1
  5048.1  5048.6  5058.3  5098.5  5102.5  5148.3  5193.1  5198.5  5208.1 5247.47
 5247.59  5247.7  5247.8  5248.5 5262.99  5263.1 5263.21    5295  5295.1    5342
  5349.1  5390.1  5402.1  5915.4  5927.4  6167.4  6197.4  6237.4  6291.2
   106.7   107.1     106     105   104.9    94.8    93.4    92.9    92.9    92.6
    92.6    92.6    92.6   93.02   93.99   93.99   97.09   97.09   97.09   97.04
   97.03   97.03   97.03   97.03   97.02   96.99   96.97   96.96   96.93   96.89
   96.87   96.86   96.83    96.8   96.79   96.77   96.77   96.76   96.73   96.72
   96.68   96.68   96.68   96.68   96.68   96.49   96.48   96.48   96.48   96.41
   96.41   96.51   96.51   96.67   96.68   97.17   97.18   97.21   97.25   97.26
   97.26   97.45   97.58   97.77   97.77    98.1    98.1   98.16   98.16   98.18
   98.21   98.23   98.25   98.25   98.23   98.23   98.21   98.18   98.18   98.17
   98.16   98.16   98.14   98.07   98.05   97.86   97.63    97.6   97.55   97.32
   97.32   97.32   97.32   97.33   97.46   97.46   94.36   93.75   93.75   93.51
   93.47   93.27   93.21   94.15    94.5    94.5    94.5    94.5    94.5
                                                                                
                                                                                
                                    87.6   87.39   87.37   87.36   87.33   87.29
   87.27   87.26   87.23    87.2   87.19   87.17
                                                                                
                                                                                
   87.66   87.85   87.98   88.17   88.17    88.5    88.5   88.56   88.56   88.58
   88.61   88.63   88.65   88.65   88.63   88.63   88.61   88.58   88.58   88.57
   88.56   88.56   88.54   88.47   88.45   88.26   88.03      88   87.95   87.72
   87.72
                                                                        
  1786.6    1872    1882    1912    1932    1942    2222    2302    2342    2362
    2392  3031.2  3231.2  3802.2  3931.2  3989.8 3989.89    3990 3990.11  3992.2
  4022.2  4032.2 4034.81 4034.93    4035  4042.2  4062.2  4072.2  4077.1  4082.2
  4087.1  4102.2  4132.2  4142.2  4152.2  4172.2  4192.2  4202.2  4216.1  4216.2
  4222.2  4242.2  4246.1    4251  4252.2    4261    4278 4278.09  4278.2 4278.31
  4279.5  4337.6  4340.4  4393.4  4395.3  4445.2  4446.4  4500.7  4502.3    4555
  4558.8  4615.9  4617.2  4631.7  4648.5  4650.1  4650.2  4678.2  4697.2  4747.3
  4748.2  4800.7  4800.9  4848.2  4848.3  4874.4  4908.3  4926.1  4943.3  4948.6
  4969.9  4973.2  4996.7  5025.5  5030.1  5037.1  5048.1  5048.6  5058.3  5098.5
  5102.5  5148.3  5193.1  5198.5  5208.1 5247.47 5247.59  5247.7  5247.8  5248.5
 5262.99  5263.1 5263.21    5295  5295.1    5342  5349.1  5390.1  5402.1  5915.4
  5927.4  6167.4  6197.4  6237.4  6291.2
   87.26   106.7   107.1     106     105   104.9    94.8    93.4    92.9    92.9
    92.6    92.6    92.6    92.6   93.02   93.99   93.99   97.09   97.09   97.09
   97.04   97.03   97.03   97.03   97.03   97.02   96.99   96.97   96.96   96.96
   96.95   96.93   96.89   96.87   96.86   96.83    96.8   96.79   96.77   96.77
   96.76   96.73   96.72   96.72   96.72   96.69   96.68   96.68   96.68   96.68
   96.68   96.49   96.48   96.48   96.48   96.41   96.41   96.51   96.51   96.67
   96.68   97.17   97.18   97.21   97.25   97.26   97.26   97.45   97.58   97.77
   97.77    98.1    98.1   98.16   98.16   98.18   98.21   98.23   98.25   98.25
   98.23   98.23   98.21   98.18   98.18   98.17   98.16   98.16   98.14   98.07
   98.05   97.86   97.63    97.6   97.55   97.32   97.32   97.32   97.32   97.33
   97.46   97.46   94.36   93.75   93.75   93.51   93.47   93.27   93.21   94.15
    94.5    94.5    94.5    94.5    94.5
                                                                                
                                                                                
                                                                                
   87.35   87.33   87.29   87.27   87.26   87.23    87.2   87.19   87.17   87.17
   87.16   87.13   87.12   87.12   87.12   87.09
                                                                                
                                                   87.66   87.85   87.98   88.17
   88.17    88.5    88.5   88.56   88.56   88.58   88.61   88.63   88.65   88.65
   88.63   88.63   88.61   88.58   88.58   88.57   88.56   88.56   88.54   88.47
   88.45   88.26   88.03      88   87.95   87.72   87.72
                                                                                
                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4748.5, 2 ,4748.5, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   80.02   89.18
     1.7     1.7
   80.82   89.98
Pier Skew, UpSta & Num, DnSta & Num=  ,4848.3, 2 ,4848.3, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   79.85   89.56
     1.7     1.7
   80.65   90.36
Pier Skew, UpSta & Num, DnSta & Num=  ,4948.6, 2 ,4948.6, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   66.55   89.65
     1.7     1.7
   67.35   90.45
Pier Skew, UpSta & Num, DnSta & Num=  ,5047.8, 2 ,5047.8, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   68.37   89.56
     1.7     1.7
   69.17   90.36
Pier Skew, UpSta & Num, DnSta & Num=  ,5148, 2 ,5148, 2 , 0 , 0 , 0 ,,
     1.7     1.7
   77.49   89.26
     1.7     1.7
   78.29   90.06
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=107.06

Type RM Length L Ch R = 1 ,41366   ,87.3,46,38.5
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 6
      3105067.49      13943111.6      3105559.25     13941141.57
        3105737.     13940418.73      3105889.07     13939889.53
      3106074.07     13939076.54      3106204.92     13938675.97
#Sta/Elev= 30
  1786.6   87.26  3026.6   89.05  3827.1   85.36  3877.1    85.9  3897.1   88.67
  3937.1    85.7  4007.1   85.77  4077.1   85.56  4107.1    79.7  4187.1   75.59
  4247.1   80.05  4277.1   85.13  4527.1   87.75  4648.5   87.42  4678.2   80.49
  4848.3   80.14  4874.4   78.45  4908.3   73.45  4926.1   68.46  4943.3   69.01
  4969.9   59.36  4996.7   57.15  5025.5   57.79  5048.1   69.14  5058.3   77.36
  5192.1   79.34  5282.1   83.42  5502.1   87.97  5922.1   91.48  6367.2   95.41
#Mann= 7 ,-1 , 0
  1786.6     .99       0  3026.6     .06       0  4007.1    .055       0
  4247.1     .06       0  4874.4    .055       0  5058.3     .06       0
  5922.1     .99       0
#XS Ineff= 2 , 0
       0    4077    93.2  5255.8       0    94.7
Permanent Ineff=
       F       F
Bank Sta=4874.4,5058.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,41320   ,75.4,48,47.4
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3105089.64     13943159.61      3105804.94     13940380.21
      3105988.95     13939644.22       3106238.5     13938655.62
#Sta/Elev= 30
  1762.5   87.87  2952.6   90.97  3832.6   86.77 3867.25   94.01 3896.72   94.91
 4012.95   87.01 4106.55    88.2 4188.82    76.5 4215.93   75.86 4272.71   77.22
 4306.27   84.03  4318.3   84.18  4650.6   83.14  4707.1   79.96  4837.1   81.86
  4863.1   80.02  4871.9    77.2  4890.9    78.3  4926.3   75.06  4949.6   63.28
  4973.2   62.08  4974.6    58.5    5007   53.85  5022.8   58.47    5044   71.49
  5069.2   71.46 5092.58   79.44  5179.1   80.59  5551.2   90.27  6410.8   98.57
#Mann= 7 ,-1 , 0
  1762.5     .99       0  2952.6     .06       0 4106.55    .055       0
  4318.3     .06       0  4926.3    .055       0 5092.58    .055       0
  5179.1     .06       0
#XS Ineff= 3 ,-1
  1762.5    4108    93.8    4318    4644   94.79    5184  6410.8    95.4
Permanent Ineff=
       F       F       F
Bank Sta=4926.3,5092.58
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,41296.5 ,,,
BEGIN DESCRIPTION:
UNION PACIFIC RAILROAD
Structure ID: K100-00-00-S5
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,27,2.6,0, 60, 60, , , .95, 0, ,,,
  1762.5  1838.3  1862.6  2298.3  2328.3  2418.3  2522.6  2772.6  2878.3  3238.3
  3258.3  3658.3  3832.6  3888.9  3918.3  3958.3  3988.3  4038.3  4119.4  4119.5
  4309.5  4309.6  4486.6  4602.6  4654.9  4655.1  4655.2  4707.7  4758.7  4837.6
  4916.5  4938.2  4991.8  5043.8  5096.1  5171.6    5174  5174.1    5229  5540.1
  5672.4  5692.4  5732.4  5752.4  5772.4  5832.4  5862.4  5902.4  5932.4  5992.4
  6052.4  6092.4  6112.4  6142.4  6212.4  6232.4  6282.4  6312.4  6370.5  6410.8
     100     100   99.93    98.5    98.3    98.3   98.02   96.93    96.2    95.3
    95.4    93.8   93.73   94.86   94.02    93.6      94    93.7      94      94
    94.9    94.9   94.86   95.03   94.92   95.05   95.11   95.12   95.28    95.4
   95.32   95.39   95.35   95.46   95.42    95.5    95.5    95.5   95.41   95.51
      95    94.3    94.6    95.2      95      95    95.8    95.5    96.2    96.6
    97.3    97.1    97.6    97.6    98.1    98.6    98.6    99.2    99.7      97
                                                                                
                                                                            88.5
    89.4                                           89.61   89.62   89.78    89.9
   89.82   89.89   89.85   89.96   89.92      90      90
                                                                                
                                                                                
  1762.5  1838.3  1862.6  2298.3  2328.3  2418.3  2522.6  2772.6  2878.3  3238.3
  3258.3  3658.3  3832.6  3888.9  3918.3  3958.3  3988.3  4038.3  4119.4  4119.5
  4309.5  4309.6  4486.6  4602.6  4654.9  4655.1  4655.2  4707.7  4758.7  4837.6
  4916.5  4938.2  4991.8  5043.8  5096.1  5171.6    5174  5174.1    5229  5540.1
  5672.4  5692.4  5732.4  5752.4  5772.4  5832.4  5862.4  5902.4  5932.4  5992.4
  6052.4  6092.4  6112.4  6142.4  6212.4  6232.4  6282.4  6312.4  6370.5  6410.8
     100     100   99.93    98.5    98.3    98.3   98.02   96.93    96.2    95.3
    95.4    93.8   93.73   94.86   94.02    93.6      94    93.7      94      94
    94.9    94.9   94.86   95.03   94.92   95.05   95.11   95.12   95.28    95.4
   95.32   95.39   95.35   95.46   95.42    95.5    95.5    95.5   95.41   95.51
      95    94.3    94.6    95.2      95      95    95.8    95.5    96.2    96.6
    97.3    97.1    97.6    97.6    98.1    98.6    98.6    99.2    99.7      97
                                                                                
                                                                            88.5
    89.4                                           89.61   89.62   89.78    89.9
   89.82   89.89   89.85   89.96   89.92      90      90
                                                                                
                                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4681.3, 2 ,4681.3, 2 , 0 , 0 , 0 ,,
       2       2
   79.57   90.62
       2       2
    84.7   95.75
Pier Skew, UpSta & Num, DnSta & Num=  ,4707.1, 2 ,4707.1, 2 , 0 , 0 , 0 ,,
       2       2
   77.39   90.62
       2       2
   82.52   95.75
Pier Skew, UpSta & Num, DnSta & Num=  ,4733.2, 2 ,4733.2, 2 , 0 , 0 , 0 ,,
       2       2
   77.35    90.7
       2       2
   82.48   95.83
Pier Skew, UpSta & Num, DnSta & Num=  ,4758.8, 2 ,4758.8, 2 , 0 , 0 , 0 ,,
       2       2
   77.77   90.78
       2       2
    82.9   95.91
Pier Skew, UpSta & Num, DnSta & Num=  ,4785, 2 ,4785, 2 , 0 , 0 , 0 ,,
       2       2
   78.54   90.81
       2       2
   83.67   95.94
Pier Skew, UpSta & Num, DnSta & Num=  ,4811.2, 2 ,4811.2, 2 , 0 , 0 , 0 ,,
       2       2
   78.88   90.82
       2       2
   84.01   95.95
Pier Skew, UpSta & Num, DnSta & Num=  ,4837.6, 2 ,4837.6, 2 , 0 , 0 , 0 ,,
       2       2
   79.19    90.9
       2       2
   84.32   96.03
Pier Skew, UpSta & Num, DnSta & Num=  ,4863.1, 2 ,4863.1, 2 , 0 , 0 , 0 ,,
       2       2
   77.13   90.86
       2       2
   82.26   95.99
Pier Skew, UpSta & Num, DnSta & Num=  ,4890.9, 2 ,4890.9, 2 , 0 , 0 , 0 ,,
       2       2
   75.64   90.84
       2       2
   80.77   95.97
Pier Skew, UpSta & Num, DnSta & Num=  ,4912.9, 2 ,4912.9, 2 , 0 , 0 , 0 ,,
       2       2
   73.73   90.82
       2       2
   78.86   95.95
Pier Skew, UpSta & Num, DnSta & Num=  ,4939.2, 2 ,4939.2, 2 , 0 , 0 , 0 ,,
       2       2
   66.66   90.89
       2       2
   71.79   96.02
Pier Skew, UpSta & Num, DnSta & Num=  ,4965.9, 2 ,4965.9, 2 , 0 , 0 , 0 ,,
       2       2
   59.59   90.89
       2       2
   64.72   96.02
Pier Skew, UpSta & Num, DnSta & Num=  ,4991.4, 2 ,4991.4, 2 , 0 , 0 , 0 ,,
       2       2
   52.57   90.85
       2       2
    57.7   95.98
Pier Skew, UpSta & Num, DnSta & Num=  ,5016.6, 2 ,5016.6, 2 , 0 , 0 , 0 ,,
       2       2
   63.32   90.88
       2       2
   68.45   96.01
Pier Skew, UpSta & Num, DnSta & Num=  ,5044, 2 ,5044, 2 , 0 , 0 , 0 ,,
       2       2
    68.3   90.96
       2       2
   73.43   96.09
Pier Skew, UpSta & Num, DnSta & Num=  ,5069.2, 2 ,5069.2, 2 , 0 , 0 , 0 ,,
       2       2
   68.89   90.94
       2       2
   74.02   96.07
Pier Skew, UpSta & Num, DnSta & Num=  ,5095.9, 2 ,5095.9, 2 , 0 , 0 , 0 ,,
       2       2
   83.49   90.92
       2       2
   88.62   96.05
Pier Skew, UpSta & Num, DnSta & Num=  ,5121.5, 2 ,5121.5, 2 , 0 , 0 , 0 ,,
       2       2
   83.53   90.93
       2       2
   88.66   96.06
Pier Skew, UpSta & Num, DnSta & Num=  ,5147.1, 2 ,5147.1, 2 , 0 , 0 , 0 ,,
       2       2
   84.59   90.99
       2       2
   89.72   96.12
Abutment Skew #Up #Dn= , 2 , 2
  4655.1  4694.8
   89.61    79.7
  4655.1  4694.8
   89.61    79.7
Abutment Skew #Up #Dn= , 2 , 2
  5132.8    5174
    79.7      90
  5132.8    5174
    79.7      90
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=98.57

Type RM Length L Ch R = 1 ,41272   ,169.7,217,328.1
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3105133.65     13943178.11      3105848.98     13940398.64
      3106032.99     13939662.61      3106282.53     13938674.03
#Sta/Elev= 30
  1762.5   87.87  2952.6   90.97  3832.6   86.77 3867.25   94.01 3896.72   94.91
 4012.95   87.01 4106.55    88.2 4188.82    76.5 4215.93   75.86 4272.71   77.22
 4306.27   84.03  4318.3   84.18  4650.6   83.14  4707.1   79.96  4837.1   81.86
  4863.1   80.02  4871.9    77.2  4890.9    78.3  4926.3   75.06  4949.6   63.28
  4973.2   62.08  4974.6    58.5    5007   53.85  5022.8   58.47    5044   71.49
  5069.2   71.46 5092.58   79.44  5179.1   80.59  5551.2   90.27  6410.8   98.57
#Mann= 7 ,-1 , 0
  1762.5     .99       0  2952.6     .06       0 4106.55    .055       0
  4318.3     .06       0  4926.3    .055       0 5092.58    .055       0
  5179.1     .06       0
#XS Ineff= 3 ,-1
  1762.5 4099.61    91.8    4318    4644   91.75 5177.73  6410.8   91.69
Permanent Ineff=
       F       F       F
Bank Sta=4926.3,5092.58
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,41055.  ,207.4,509,513.6
BEGIN DESCRIPTION:
K100-00-00-S5_UPRR -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
 3105353.301499813942783.5681155      3105999.96      13940229.8
      3106179.14     13940135.39      3106583.76     13938743.79
#Sta/Elev= 30
  2261.8   89.74  2361.8   87.74  3211.8   90.02  3601.8   86.72  3911.8   83.07
  4281.8   81.59  4311.8   76.02  4341.8   64.26  4371.8    75.4  4421.8    82.2
  4511.8   78.72  4651.8   81.95  4791.8   80.56  4841.8   82.95  4891.8   78.09
  4916.2   70.38 4941.01    70.3 4950.74   64.75 4973.05   61.59 4974.37   58.93
 4990.63   55.27    5005   54.29 5021.96   58.09  5066.2   79.77  5098.7   90.03
  5208.7   91.24  5608.7   88.84  5658.7   85.94  5738.7    86.2    6548   97.57
#Mann= 6 ,-1 , 0
  2261.8     .08       0  3601.8     .12       0  4281.8    .055       0
  4421.8     .12       0  4841.8    .055       0  5098.7     .14       0
#XS Ineff= 2 ,-1
  2261.8 4155.07   91.72    4500    4700   91.75
Permanent Ineff=
       F       F
Bank Sta=4841.8,5098.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,40546   ,813.5,757,571.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X18A
END DESCRIPTION:
XS GIS Cut Line= 4
      3105332.06     13943260.31      3106014.58     13940713.35
      3106640.88     13940503.44      3106899.72     13938590.77
#Sta/Elev= 30
    2280    87.7    2550    83.1    2620    85.3    2640    82.6    2760      87
    2980    86.6    3060    81.2    3170    83.6    3260    89.8    3750    89.4
    4330    81.7    4570    84.3  4623.3   81.77    4800    80.5    4880    63.8
    4890    64.3    4910    76.9  4934.4    75.5    4982   56.27  5000.3   55.31
    5018   56.25  5065.5   70.32    5107   74.94  5216.8    82.9  5366.8    83.9
  5466.8    90.1  6687.4    88.4  7187.4    97.5  7448.4   98.85  7507.5   101.2
#Mann= 5 ,-1 , 0
    2280     .12       0  4623.3     .14       0  4934.4    .055       0
    5107     .14       0  7448.4     .99       0
#XS Ineff= 2 , 0
         4285.16   91.53 6646.48           91.12
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
    2000    3340      90
Bank Sta=4934.4,5107
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,39789   ,2053.3,1639,958.9
BEGIN DESCRIPTION:
Cross Section Xs18.1
END DESCRIPTION:
XS GIS Cut Line= 5
      3105546.54      13944216.8      3106731.19     13941068.83
      3106768.16     13940971.37      3106934.25     13940450.24
      3107085.29     13938574.59
#Sta/Elev= 30
  1581.4      83  1711.4    93.5  1821.4    80.4  2641.4    80.8  2671.4    81.8
  2721.4    93.2  3121.4    97.4  3321.4    93.6  3361.4    86.5  3391.4    84.9
  3421.4    88.6  3481.4    89.7  3521.4    83.2  3631.4    74.7  3691.4    73.3
  3761.4    80.8  4061.4    87.7  4351.4    85.5  4611.4    78.1  4751.4    80.1
  4861.4    75.2    4955    67.3  4995.9   54.66    5045      61  5089.2    82.2
  5269.2    88.2  6896.2    90.3  7406.2    98.2  7446.2   101.9  7477.9   101.8
#Mann= 5 ,-1 , 0
  1581.4      .1       0  3521.4     .14       0  4751.4    .055       0
  5089.2     .14       0  7406.2     .99       0
#XS Ineff= 2 , 0
         3515.62   91.66
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
  1711.4  2770.4   93.47
Bank Sta=4751.4,5089.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,38150   ,270,400,497
BEGIN DESCRIPTION:
Cross Section K100-00-00-X18
END DESCRIPTION:
XS GIS Cut Line= 4
       3106177.5     13944778.27      3108121.95     13941868.55
      3107701.08     13941604.15        3107615.     13938569.93
#Sta/Elev= 30
  1184.2    96.3  1694.2    92.4  2354.2    95.6  2884.2    94.4  3244.2    84.7
  3704.2      79  3914.2    79.2  4144.2    85.5  4514.2    77.3  4683.8    75.9
  4803.8    79.1  4884.6   77.38  4901.3   74.41  4922.1   65.42  4995.9   53.26
  5012.5   54.42  5019.6    60.7  5040.1   71.31  5061.3   76.92  5370.8    89.8
  5730.8    81.8  6350.8      88  6745.5   88.88  6920.8    87.3  7547.4   89.83
  7970.8    90.5  8150.8    94.3  8166.2   97.58  8180.8   101.6  8216.3   104.2
#Mann= 6 ,-1 , 0
  1184.2     .14       0  4884.6    .055       0  5061.3     .14       0
  6745.5      .1       0  7547.4     .14       0  8166.2     .99       0
#XS Ineff= 2 , 0
         3914.06   88.29
Permanent Ineff=
       F       F
Bank Sta=4884.6,5061.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,37750   ,130,36,120
XS GIS Cut Line= 6
 3107294.562822213943289.6201518 3108111.1320552 13942091.631078
 3108175.852398213941865.8191936 3108255.322055613941543.7968718
  3108109.72162513940506.9282106 3108222.568840213939083.3172127
#Sta/Elev= 30
    3130   90.71  3488.7   84.42  3862.4   82.68  4161.3   86.83  4295.8   86.91
  4430.4   84.84  4726.6   76.46    4780    76.6    4810      76    4889    71.7
    4969    50.9    4987   50.16  4992.3    53.2  5013.5   59.08  5014.9   60.71
  5030.7   56.31    5046    55.8    5096    81.1    5171    82.2  5340.9   80.58
  5610.1   85.41  5744.7   82.96  5969.1    82.3  6624.8   87.45  6714.1   80.32
  6803.4   87.85  6996.7   88.73    7205   87.33  7383.5   88.95  7621.5   90.85
#Mann= 7 ,-1 , 0
    3130     .14       0    4780    .035       0    4969    .055       0
    5046    .035       0    5171     .14       0  6996.7      .1       0
  7383.5     .14       0
#XS Ineff= 3 ,-1
    4444    4824    84.3    5177    5740    84.9    6630    6800    86.5
Permanent Ineff=
       F       F       T
Bank Sta=4810,5096
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,37732   ,,,
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,16,2.6,0, 51, 51, , , .95, 0, 0,0,,
    4424  4615.8    4640  4665.8  4691.5  4711.9  4732.8  4742.9  4767.9  4792.9
  4817.9  4834.9  4834.9  4842.9  4867.9  4892.9  4917.9  4942.1  5166.6  5166.6
  5167.9  5192.9  5217.3    5242  5257.8  5273.5  5289.3    5305  5316.5  5320.1
    5324    5328  5339.5    5351  5371.8  5392.5  5413.3  5413.4  5432.3    5434
    5457    5480    5503    5526  5535.6  5714.5  5738.4  5750.9  5760.5    5786
  5808.8
    84.3    84.3   84.34   84.74   85.51   86.38   87.39   87.87   88.98   89.95
   90.76    91.2    91.2   91.43   91.94   92.31   92.53    92.6    92.6    92.6
    92.6   92.52   92.29   91.91   91.38    90.7   89.87    88.9   87.77   87.39
   86.97   86.56   85.63   85.06   84.86   85.03   85.57   85.58   86.23   86.29
   86.89   87.29   87.47   87.45   87.34   84.87   84.24   83.74   83.39   82.71
    82.4
      67      67      67      67      67      67      67      67      67      67
      67      67    87.2   87.43   87.94   88.31   88.53    88.6    88.6      67
      67      67      67      67      67      67      67      67      67      67
      67      67      67      67      67      67      67      67      67      67
      67      67      67      67      67      67      67      67      67      67
      67
    4424  4615.8    4640  4665.8  4691.5  4711.9  4732.8  4742.9  4767.9  4792.9
  4817.9  4834.9  4834.9  4842.9  4867.9  4892.9  4917.9  4942.1  5166.6  5166.6
  5167.9  5192.9  5217.3    5242  5257.8  5273.5  5289.3    5305  5316.5  5320.1
    5324    5328  5339.5    5351  5371.8  5392.5  5413.3  5413.4  5432.3    5434
    5457    5480    5503    5526  5535.6  5714.5  5738.4  5750.9  5760.5    5786
  5808.8
    84.3    84.3   84.34   84.74   85.51   86.38   87.39   87.87   88.98   89.95
   90.76    91.2    91.2   91.43   91.94   92.31   92.53    92.6    92.6    92.6
    92.6   92.52   92.29   91.91   91.38    90.7   89.87    88.9   87.77   87.39
   86.97   86.56   85.63   85.06   84.86   85.03   85.57   85.58   86.23   86.29
   86.89   87.29   87.47   87.45   87.34   84.87   84.24   83.74   83.39   82.71
    82.4
      67      67      67      67      67      67      67      67      67      67
      67      67    87.2   87.43   87.94   88.31   88.53    88.6    88.6      67
      67      67      67      67      67      67      67      67      67      67
      67      67      67      67      67      67      67      67      67      67
      67      67      67      67      67      67      67      67      67      67
      67
Pier Skew, UpSta & Num, DnSta & Num=  ,4939.9, 2 ,4939.9, 2 , 0 , 0 , 0 ,,
       3       3
      49    88.6
       3       3
      49    88.6
Pier Skew, UpSta & Num, DnSta & Num=  ,5128.8, 2 ,5128.8, 2 , 0 , 0 , 0 ,,
       3       3
      49    88.6
       3       3
      49    88.6
BR Coef=-1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,

Type RM Length L Ch R = 1 ,37714   ,566.5,900,1146.4
XS GIS Cut Line= 6
 3107472.149081213943336.1118567 3108201.492438813942270.8331474
 3108175.635207113942012.9242144 3108338.678188113941341.0128286
 3108224.094755813940479.9016899  3108342.15029413939151.7767215
#Sta/Elev= 30
    3135   93.12  3298.2   90.62  3847.3   88.89    4337   90.57  4440.4   88.93
    4570    82.9  4613.2   68.51    4642   76.68  4670.8   79.89    4787    75.7
    4817      75    4894      71    4974    50.7    4997   50.02  4999.6   50.89
  5001.5      54    5024   61.47    5048      56    5099    80.9    5186      82
  5421.6   79.53  5691.2   83.62  5900.9   80.95  6664.8   88.16  6694.8   86.54
  6724.8   81.18  6784.7   85.75  6949.5   87.03    7324   88.89  7578.7   90.66
#Mann= 7 ,-1 , 0
    3135     .14       0    4787    .035       0    4974    .055       0
    5048    .035       0    5186     .14       0  6949.5      .1       0
    7324     .14       0
#XS Ineff= 3 ,-1
    4540    4824    83.8    5177    5740    84.4    6680    6820      86
Permanent Ineff=
       F       F       T
Bank Sta=4817,5099
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,36814   ,1377.7,1322,1155.9
BEGIN DESCRIPTION:
Cross Section Xs17.5
END DESCRIPTION:
XS GIS Cut Line= 5
      3107994.84      13943332.6      3109037.82     13941849.98
       3109070.6     13941804.08      3109867.57     13940495.07
      3110370.44     13938084.19
#Sta/Elev= 30
  3160.6    96.3  4080.6    87.8  4370.6    77.4  4460.6    78.5  4520.6    75.5
  4700.6    74.4  4740.6    77.8  4810.6    78.9  4860.6    76.8    4928   77.73
    4938   76.03    4987    54.2  5003.5    51.9  5049.2   57.17    5069   65.43
  5089.8      83  5119.8    80.3  5169.8    80.2  5349.8    87.1  5419.8    87.5
  5659.8    82.5  6039.8    80.4  6139.8    84.3  6239.8      82  6612.3    86.8
  7832.3    86.6  8092.3    92.7  8322.3    92.8  8922.3    99.2  9025.1   100.2
#Mann= 4 ,-1 , 0
  3160.6     .14       0    4928    .055       0  5089.8     .14       0
  8922.3     .99       0
#XS Ineff= 2 , 0
         4421.88    86.4 6739.26           87.35
Permanent Ineff=
       F       F
Bank Sta=4928,5089.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,35492   ,679.5,870,837.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X17
Located At: 5500' D/S HARDY TOLL ROAD
END DESCRIPTION:
XS GIS Cut Line= 3
      3109590.06     13943389.53      3110502.31     13941727.85
      3111068.56     13938465.33
#Sta/Elev= 30
    3608    95.9    3878    96.5  4172.3   90.28    4388    89.6    4668    79.6
    4718      75  4907.9    77.8    4938    74.7    4987   52.87  5003.5   50.57
  5049.2   55.84    5069    64.1    5078    73.2  5087.9    78.6    5108    83.6
    5158      78    5328    78.2  5553.6    85.3  5763.6    85.2  5953.6    82.6
  6063.6    78.4  6113.6    78.6  6153.6    81.7  6203.6    78.7  6353.6    80.6
  6493.6    85.5  6613.6    86.7  7833.6    85.7  8543.6    93.9  8814.9    99.4
#Mann= 4 ,-1 , 0
    3608      .1       0  4172.3     .14       0  4907.9    .055       0
  5087.9     .14       0
Bank Sta=4907.9,5087.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,34622   ,1353.3,1150,1106.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X16
Located At: 2300 FT U/S ALDINE WESTFIELD RD
END DESCRIPTION:
XS GIS Cut Line= 3
      3110195.03     13943640.58      3111418.11     13941515.28
       3112075.5     13938500.06
#Sta/Elev= 30
  3234.6    96.5  3624.6    90.7  3664.6    88.7  3794.6    88.4  4094.6    81.8
  4454.6    79.5  4624.6    80.8  4684.6    77.2  4764.6    76.2  4834.6    72.7
  4898.8   76.62  4928.3    73.4  4953.5   62.23  4977.9   53.72  4980.1   49.65
  5022.1   50.06  5044.8    58.8    5074   75.71    5102   77.54  5184.6      79
  5524.6    76.4  5684.6    81.2  5836.7    77.8  6006.7    79.4  6206.7    85.6
  6346.7    86.3  7296.7      85  7376.7    87.3  7816.7    89.5  8772.8    98.7
#Mann= 3 ,-1 , 0
  3234.6     .14       0  4898.8    .055       0    5102     .14       0
#XS Ineff= 2 , 0
                          6345.7           86.38
Permanent Ineff=
       F       F
Bank Sta=4898.8,5102
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,33472   ,861.8,1087,662.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X15
Located At: 1300 FT U/S ALDINE WESTFIELD RD
END DESCRIPTION:
XS GIS Cut Line= 4
        3111888.     13944312.56      3111945.43     13942889.73
      3112381.06     13942041.72      3112867.17     13938958.39
#Sta/Elev= 30
  3301.3    94.1  3551.3    90.9  3652.8   87.31  3921.3    81.8  3981.3    78.7
  4121.3    77.4  4451.3    79.2  4721.3    78.4  4785.3    80.1  4865.3    78.4
    4888   80.47  4915.2   79.21  4934.4    75.3  4960.3   61.88  4984.8   52.88
  4999.9   50.41  5014.6    52.9  5083.1   80.85  5113.2   80.78  5165.6   75.81
  5235.3    77.4  5375.3    74.1  5575.3    74.8  5708.6    73.2  5848.6    75.3
  6058.6    82.8  7383.3   84.32  8068.6    89.5  8138.6    91.7  8800.1    99.4
#Mann= 5 ,-1 , 0
  3301.3      .1       0  3652.8     .14       0  4915.2    .055       0
  5083.1     .14       0  7383.3     .12       0
#XS Ineff= 2 , 0
       0                 6117.19       0    84.3
Permanent Ineff=
       F       F
Bank Sta=4915.2,5083.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,32385.  ,187.8,170,140.8
BEGIN DESCRIPTION:
K100-00-00-S4_ALDINE WESTFIELD -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 5
      3112572.38      13944141.2      3112718.16      13943490.3
      3112816.81     13943385.57      3112898.75     13942963.86
      3113394.49     13939024.99
#Sta/Elev= 30
  4255.5   95.12  4345.5   93.88  4685.5   74.47  4855.5    73.8  4885.5    76.5
  4915.5   76.08 4978.36   53.16 4998.17   50.72 5022.63   53.67  5052.5   65.78
  5076.4   71.83  5196.4    78.2  5256.4   76.32    5596   79.26    5726   78.08
    5836   80.76    5946   78.19    6136   79.26    6206   82.64    6296   79.52
    6556    84.8    6746   81.78    6966   81.38    7256   83.55    7476    82.2
    7606   84.23    7746   86.76    7986    84.8    8496   87.03  9465.9   96.91
#Mann= 4 ,-1 , 0
  4255.5      .1       0  4915.5    .055       0  5076.4     .14       0
    7606     .06       0
#XS Ineff= 2 , 0
                         5834.52           83.85
Permanent Ineff=
       F       F
Bank Sta=4915.5,5076.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,32215   ,85.7,85,84.7
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
      3112729.46      13944177.3      3113029.66     13943025.12
       3113531.1     13939159.11
#Sta/Elev= 30
  4346.7    95.2  4456.7    91.6  4522.6   87.16  4626.7    81.6    4650   82.41
  4922.1   73.87  4978.4   52.79  4997.9   50.77  5021.4   52.73  5031.2   55.72
  5061.8   70.05    5103   72.72  5272.3   77.28  5687.3    80.6  5867.3    80.9
  5957.3    77.8  6237.3    79.9  6277.3      83  6337.3    81.1  6657.3    84.2
  6787.3    81.6  7327.3    81.9  7387.3    80.7  7607.3      84  7847.3    85.3
  8347.3    85.2  8747.3    88.8  8857.3    88.5  9087.3    92.3  9435.7      95
#Mann= 4 ,-1 , 0
  4346.7     .99       0  4522.6      .1       0  4922.1    .055       0
  5061.8     .14       0
#XS Ineff= 2 , 0
       0    4831    91.6 5353.52       0    83.4
Permanent Ineff=
       F       F
Bank Sta=4922.1,5061.8
XS Rating Curve= 0
Exp/Cntr=.5,.3
