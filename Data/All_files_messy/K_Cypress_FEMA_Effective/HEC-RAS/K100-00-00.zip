HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,209229  ,921.3,1323,1172.6
BEGIN DESCRIPTION:
Cross Section XS77
END DESCRIPTION:
XS GIS Cut Line= 6
 2989502.019025313916319.3878118      2990276.16       13911596.
      2990360.85     13911395.83      2990399.06     13911304.13
      2990473.81     13911132.31 2990249.358621113908813.1953308
#Sta/Elev= 30
    59.7   163.9   939.7   157.2   989.7   155.4  3829.7   153.3  4199.7   152.3
  4269.7   153.7  4349.7   151.5  4569.7     151  4799.7   151.1  4916.2   153.5
    4975  150.05  4985.1  147.61  4994.9  140.33  4999.4  139.14  5013.8  144.01
  5023.5  151.22  5056.2     152  5083.5   156.2  5143.5   151.6  5252.9   153.2
  5272.9   151.7  5332.9   153.3  5380.2   156.5  5400.2   154.3  5450.2     154
  5730.2   156.9  5990.2   155.5  6230.2   157.7  7070.2   157.4  7680.2   159.1
#Mann= 6 ,-1 , 0
    59.7     .06       0  3829.7     .14       0  4916.2     .12       0
    4975     .04       0  5023.5     .14       0  5730.2     .06       0
#XS Ineff= 2 , 0
         2799.59   154.6 5083.41           156.2
Permanent Ineff=
       T       T
Bank Sta=4916.2,5023.5
XS Rating Curve= 0
Vertical n Elevations= 2
  139.14  156.72
Vertical n for Station=59.7
     .24     .24
Vertical n for Station=3829.7
     .99     .99
Vertical n for Station=4916.2
     .04     .07
Vertical n for Station=5023.5
     .99     .99
Vertical n for Station=5730.2
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,207906  ,829.9,922,965
BEGIN DESCRIPTION:
Cross Section K100-00-00-X76
END DESCRIPTION:
XS GIS Cut Line= 4
  2989901.01992913916066.6354692      2991498.17     13911449.86
      2991594.04     13911162.28 2991290.915254113908710.9350155
#Sta/Elev= 30
   -42.4   160.8   647.6   154.5  2567.6   154.8  4027.6   152.7  4407.6   150.3
  4902.8   151.8  4932.8   152.1 4942.21  154.74  4985.1  148.08  4994.9   140.8
  4999.4  139.61  5013.8  144.48  5023.5  151.69  5077.3  161.73  5109.5  162.33
  5149.4  160.83    5166   150.4    5216   154.2    5236   151.7    5286     151
    5376   152.8    5536   151.3    5576   154.8    5616   153.6    5666   156.4
    5796     154    6026   158.8    6226   154.5    6386   157.5    7616   157.8
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
       0 2567.58   154.8 5108.27       0  162.32
Permanent Ineff=
       T       T
Bank Sta=4942.21,5023.5
XS Rating Curve= 0
Vertical n Elevations= 2
  139.61  155.47
Vertical n for Station=-42.4
     .24     .24
Vertical n for Station=3937.8
     .99     .99
Vertical n for Station=4942.21
     .04     .07
Vertical n for Station=5023.5
     .99     .99
Vertical n for Station=5651.3
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,206984  ,1481.7,1578,934.5
BEGIN DESCRIPTION:
Cross Section Xs75
END DESCRIPTION:
XS GIS Cut Line= 5
 2990197.051339613916587.4790249      2992245.54     13911930.12
      2992408.66     13911593.36      2992497.38     13911419.31
 2992088.616427713909115.1988336
#Sta/Elev= 30
  -245.2   162.6   154.8   157.7  1034.8   153.6  2464.8   154.1  3654.8     154
  4034.8   151.6  4244.8   152.7  4374.8   150.5  4404.8   151.6  4524.8   149.7
  4814.8   150.1  4932.8     152    4975  149.16  4985.1  146.72  4994.9  139.44
  4999.4  138.25  5032.8   147.6  5052.8   150.6  5082.8     153  5132.8   148.3
    5217   150.6    5287   148.3    5337   154.5    5387   151.5  5412.4   152.1
  6042.4   151.9  6082.4   153.1  6272.4   152.4  6422.4   155.1  7752.4   158.6
#Mann= 9 ,-1 , 0
  -245.2     .06       0  2464.8     .12       0  4374.8     .14       0
  4932.8     .12       0    4975     .04       0  5052.8     .12       0
  5082.8     .14       0  5412.4     .12       0  6082.4     .06       0
#XS Ineff= 2 , 0
         2974.73   154.4 5899.66          157.04
Permanent Ineff=
       T       T
Bank Sta=4932.8,5082.8
XS Rating Curve= 0
Vertical n Elevations= 2
  138.25  154.79
Vertical n for Station=-245.2
     .24     .24
Vertical n for Station=2464.8
     .48     .48
Vertical n for Station=4374.8
     .99     .99
Vertical n for Station=4932.8
     .04     .07
Vertical n for Station=5082.8
     .99     .99
Vertical n for Station=5412.4
     .48     .48
Vertical n for Station=6082.4
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,205406  ,702.3,821,817.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X74
END DESCRIPTION:
XS GIS Cut Line= 4
 2990747.694985913916916.0508472      2993503.56     13912835.01
      2993507.21     13912630.75  2992730.96945913909146.1547582
#Sta/Elev= 30
   -28.7   159.5   571.3   155.3   801.3   154.9   861.3   153.6  3395.8  152.13
  3811.3   153.7  4421.3   152.9  4578.5  151.52  4976.4  148.88    4980  145.94
  4987.2  144.77  4992.4  136.18  4999.7  135.93  5007.8  136.59  5013.7  142.44
  5023.5  145.84  5039.6  145.57  5050.4  150.36    5300   150.1    5350   147.9
  5372.7  151.15    5380   152.2    5440   151.4    6410     152    6440   153.2
    6530   151.8  6769.8   152.7    6870   152.7    6950   154.8    8670   157.3
#Mann= 7 ,-1 , 0
   -28.7     .06       0  3395.8     .12       0  4578.5     .14       0
  4976.4     .04       0  5050.4     .14       0  5372.7     .12       0
  6769.8     .06       0
#XS Ineff= 2 , 0
         3810.98   153.7
Permanent Ineff=
       T       T
Bank Sta=4976.4,5050.4
XS Rating Curve= 0
Vertical n Elevations= 2
  135.93  153.95
Vertical n for Station=-28.7
     .24     .24
Vertical n for Station=3395.8
     .48     .48
Vertical n for Station=4578.5
     .99     .99
Vertical n for Station=4976.4
     .04     .07
Vertical n for Station=5050.4
     .99     .99
Vertical n for Station=5372.7
     .48     .48
Vertical n for Station=6769.8
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,204585  ,1164.9,1182,1069.2
BEGIN DESCRIPTION:
Cross Section XS73
END DESCRIPTION:
XS GIS Cut Line= 4
 2991376.599823813917380.2553699      2994218.47     13912953.89
      2994292.31     13912707.75 2993147.618063513908417.8925631
#Sta/Elev= 30
  -445.9   159.7   734.1   154.2  3454.1   150.9  3864.1   152.8  4454.1   152.2
  4514.1   150.6  4584.1   151.3  4874.2   148.3  4954.2     149  4976.4  148.05
    4980  145.11  4987.2  143.94  4992.4  135.35  4999.7   135.1  5007.8  135.76
  5013.7  141.61  5023.5  145.01  5050.4  150.36  5054.2     152  5091.2   151.2
  5121.2   149.1  5221.2   148.4  5341.2   148.5  5371.2   149.3  5391.2   151.4
  6781.2   151.8  6961.2   153.4  8091.2   156.4  8651.2   155.5  9511.2     157
#Mann= 8 ,-1 , 0
  -445.9     .06       0  3454.1     .12       0  4514.1     .14       0
  4584.1      .1       0  4976.4     .04       0  5054.2     .14       0
  5221.2     .12       0  5391.2     .06       0
#XS Ineff= 2 , 0
         3864.12   152.8 6794.61          156.99
Permanent Ineff=
       T       T
Bank Sta=4976.4,5054.2
XS Rating Curve= 0
Vertical n Elevations= 2
   135.1  153.56
Vertical n for Station=-445.9
     .24     .24
Vertical n for Station=3454.1
     .48     .48
Vertical n for Station=4514.1
     .99     .99
Vertical n for Station=4584.1
      .4      .4
Vertical n for Station=4976.4
     .04     .07
Vertical n for Station=5054.2
     .99     .99
Vertical n for Station=5221.2
     .48     .48
Vertical n for Station=5391.2
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,203403  ,899.2,981,1048.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X72
END DESCRIPTION:
XS GIS Cut Line= 4
  2993463.68476713917500.2911245      2995407.22     13912611.72
      2995288.06     13912286.17 2993689.386449913907643.7140696
#Sta/Elev= 30
  -340.7   158.8  -250.7   155.7   869.3   153.5    2526  153.38  3811.7  149.05
  4009.3   148.2  4059.3   146.1  4129.3     149  4179.3     147  4349.3   149.2
  4389.3   146.4  4749.3   149.8  4859.3   152.8  4953.8  151.53  4961.6  150.84
  4972.1  144.18  4990.8  139.76  4999.2  133.89    5012  136.29  5012.2  140.98
  5036.8  145.33  5044.6  149.43  5092.1  153.28  5163.4   154.1  5211.1  151.54
  5296.7   153.7  5366.7   151.6  6581.7  151.42  8686.7     156 10176.7   156.9
#Mann= 9 ,-1 , 0
  -340.7     .06       0    2526     .12       0  3811.7     .14       0
  4953.8     .12       0  4961.6     .04       0  5044.6     .12       0
  5092.1     .14       0  5211.1     .12       0  6581.7     .06       0
#XS Ineff= 2 , 0
         4919.95   153.1 5162.11           154.1
Permanent Ineff=
       T       T
Bank Sta=4953.8,5092.1
XS Rating Curve= 0
Vertical n Elevations= 2
  133.89  153.04
Vertical n for Station=-340.7
     .24     .24
Vertical n for Station=2526
     .48     .48
Vertical n for Station=3811.7
     .99     .99
Vertical n for Station=4953.8
     .04     .07
Vertical n for Station=5092.1
     .99     .99
Vertical n for Station=5211.1
     .48     .48
Vertical n for Station=6581.7
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,202422  ,1235.1,1133,1075.6
BEGIN DESCRIPTION:
Cross Section Xs70.5
END DESCRIPTION:
XS GIS Cut Line= 4
 2993832.1441206 13917578.569149      2996338.47     13912495.78
      2996338.47     13912241.36 2994976.434739413908811.8999662
#Sta/Elev= 30
  -783.6   156.1  -183.6     154  2296.4   152.8  2726.4   152.6  3316.4     148
  3616.4   146.8  3936.4   148.6  3966.4   146.4  4016.4   148.7  4126.4   148.8
  4186.4   147.2  4266.4   148.6  4960.5   147.2  4967.2  143.57  4983.1  142.78
  4989.5  137.03  5000.7   133.9  5012.5     137  5017.6  141.86  5033.8  147.11
  5052.2  148.82  5053.6   150.5  5073.6   152.6  5123.6   145.9    5158   147.6
    5438   145.7    5488   152.3    6278   151.3    7468   155.9    8828   156.1
#Mann= 6 ,-1 , 0
  -783.6     .06       0  2296.4     .12       0  3316.4     .14       0
  4960.5     .04       0  5052.2     .12       0    5488     .06       0
#XS Ineff= 2 , 0
                         5073.59           152.6
Permanent Ineff=
       T       T
Bank Sta=4960.5,5052.2
XS Rating Curve= 0
Vertical n Elevations= 2
   133.9   152.7
Vertical n for Station=-783.6
     .24     .24
Vertical n for Station=2296.4
     .48     .48
Vertical n for Station=3316.4
     .99     .99
Vertical n for Station=4960.5
     .04     .07
Vertical n for Station=5052.2
     .48     .48
Vertical n for Station=5488
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,201289  ,949.4,709,647.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X70
END DESCRIPTION:
XS GIS Cut Line= 4
 2994642.733652413917038.6693856        2997479.     13912548.91
      2997458.52      13912325.5 2995655.018077213908411.0276786
#Sta/Elev= 30
  -430.7  155.28  -430.7   154.6  1929.3   154.3  2539.3   150.8  2790.5  152.86
  4731.1  147.73  4879.9   148.2  4899.9   148.9  4917.5  153.85  4934.9  149.14
  4960.5  147.22  4967.2  143.59  4983.1   142.8  4989.5  137.05  5000.7  133.92
  5012.5  137.02  5017.6  141.88  5033.8  147.13  5052.2  148.84  5068.7  153.32
  5090.1  153.14  5103.1  148.11  5124.2   145.9  5464.2   147.4  5564.2   145.4
  5820.3  148.25  5904.2   151.2  6364.2     155  6754.2   153.5  9414.2   155.7
#Mann= 6 ,-1 , 0
  -430.7     .06       0  2790.5     .12       0  4731.1     .14       0
  4960.5     .04       0  5052.2     .14       0  5820.3     .06       0
#XS Ineff= 2 , 0
                         5068.83          153.31
Permanent Ineff=
       T       T
Bank Sta=4960.5,5052.2
XS Rating Curve= 0
Vertical n Elevations= 2
  133.92  152.22
Vertical n for Station=-430.7
     .24     .24
Vertical n for Station=2790.5
     .48     .48
Vertical n for Station=4731.1
     .99     .99
Vertical n for Station=4960.5
     .04     .07
Vertical n for Station=5052.2
     .99     .99
Vertical n for Station=5820.3
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,200580  ,839.1,1409,1527.9
BEGIN DESCRIPTION:
Cross Section Xs68.5
END DESCRIPTION:
XS GIS Cut Line= 5
 2996271.728390813915639.0905218      2998173.23      13912942.2
      2998172.26     13912669.68      2998163.33     13912402.04
  2996630.02164513909155.9281443
#Sta/Elev= 30
  1268.7   155.6  1428.7   153.9  1848.7   153.5  2748.7   154.6  2878.7   152.2
  3388.7   153.1  4108.7     149  4458.7   148.9  4768.5     146  4871.1   146.4
  4921.1   148.2  4951.1   146.3    4976  143.13  4982.3   137.7  5000.1  133.63
 5004.11  133.63  5012.5  141.33  5021.1   144.6  5091.1     147  5208.9   145.9
  5598.9   147.4  5688.9   148.3  5728.9   152.4  5758.9   148.2  5778.9   146.2
  5798.9     148  6008.9   150.6  6598.9   155.2  7928.9     154  8698.9  155.05
#Mann= 8 ,-1 , 0
  1268.7     .06       0  2878.7     .12       0  4768.5     .14       0
  4921.1     .12       0  4951.1    .048       0  5021.1     .12       0
  5091.1     .14       0  5758.9     .06       0
#XS Ineff= 2 , 0
                         5728.88           152.4
Permanent Ineff=
       T       T
Bank Sta=4921.1,5091.1
XS Rating Curve= 0
Vertical n Elevations= 2
  133.63  151.93
Vertical n for Station=1268.7
     .24     .24
Vertical n for Station=2878.7
     .48     .48
Vertical n for Station=4768.5
     .99     .99
Vertical n for Station=4921.1
     .04     .07
Vertical n for Station=5091.1
     .99     .99
Vertical n for Station=5758.9
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,199171  ,1733.3,1175,1248.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X68
END DESCRIPTION:
XS GIS Cut Line= 5
 2997736.527411113914592.4160018      2999494.47     13912304.52
      2999515.65     13912037.32      2998945.37     13910278.43
  2998464.50841813909565.4287033
#Sta/Elev= 30
  2033.6   155.1  3013.6   149.7  3693.6   150.3  4153.6     148  4373.6   149.2
  4523.6   148.6  4663.6   145.2  4945.4  147.26  4959.1  141.08    4976  142.56
  4982.3  137.13  5000.1  133.06  5005.3  133.78  5012.5  140.76    5019  143.04
    5023  147.04  5336.9     148  5376.9   151.1  5386.9   150.6  5406.9   145.5
  5426.9   144.1  5496.9   148.5  5846.9   147.6  5886.9   149.6  5976.9   149.1
  6136.9   151.8  7125.9   154.4  7815.9   153.9  7855.9   151.2  7895.9   154.8
#Mann= 0 ,-1 , 0
#XS Ineff= 6 ,-1
    4000 4883.58   147.7    5073    5706  152.19    5706    5916  152.18
    5916    6258  152.35    6258    6754  154.88    6754  7895.9  156.49
Permanent Ineff=
       T       T       T       T       T       T
Bank Sta=4945.4,5023
XS Rating Curve= 0
Vertical n Elevations= 2
  133.06  151.17
Vertical n for Station=2033.6
     .24     .24
Vertical n for Station=2317.3
     .48     .48
Vertical n for Station=4524.1
     .99     .99
Vertical n for Station=4945.4
     .04     .07
Vertical n for Station=5023
     .99     .99
Vertical n for Station=5546.1
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,197996  ,1384.5,1605,997.2
BEGIN DESCRIPTION:
Cross Section Xs66.5; Large mound of soil on left bank, see aerial
END DESCRIPTION:
XS GIS Cut Line= 6
  2998779.30181813916028.5051673      3000634.78     13913420.88
      3000633.04      13912557.8      3000643.48     13912284.25
      3000685.61     13911141.85 2999709.361501313910029.5616321
#Sta/Elev= 30
   809.3     154  1789.3   149.8  2059.3   154.3  2199.3   151.4  2239.3   146.8
  2279.3   148.6  2349.3   158.3  2409.3   172.2  2519.3     185  2539.3   184.7
  2669.3   159.7  2769.3   153.5  3919.3   149.2  3969.3   148.5  4009.3   143.1
  4069.7   149.6  4189.7     141  4249.7   148.5  4972.8   142.9  4982.3  136.13
  5000.1  132.06    5023  146.04  5082.8   152.3  5224.8     146  5284.8     134
  5970.8     134  5990.8     140  6087.8     150  7729.7   151.8  7769.7   155.4
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
         4817.56  145.68 5082.89           152.3
Permanent Ineff=
       T       T
#Block Obstruct= 2 , 0
       0                  5224.8       0     146
Bank Sta=4972.8,5082.8
XS Rating Curve= 0
Vertical n Elevations= 2
  132.06  150.44
Vertical n for Station=809.3
     .24     .24
Vertical n for Station=2769.3
     .48     .48
Vertical n for Station=4189.7
     .99     .99
Vertical n for Station=4972.8
     .04     .07
Vertical n for Station=5082.8
     .99     .99
Vertical n for Station=5142.3
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,196391  ,862.8,719,766.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X66
END DESCRIPTION:
XS GIS Cut Line= 5
 3000472.132540513915956.9192966       3001910.7     13913816.37
      3002235.54     13912545.83      3002224.96     13912239.02
 2999819.143391813909547.5542836
#Sta/Elev= 30
  1014.2   153.6  2224.2   147.2  2264.2   151.5  3613.2   147.7  3843.2   146.5
  3873.2   142.2  3953.2   151.2  4033.2   140.9  4133.2   147.2  4883.2   142.4
  4925.1  152.99  4961.8  145.96  4997.9   130.7  5009.6  131.28  5015.9  141.54
    5039  145.32  5059.2  151.44    5060  146.95  5090.6  151.59  5114.9  144.64
  5591.6   147.1  5707.4     146  5777.4     140  5897.4     150  5997.4     134
  6047.4     134  6217.4     150  8741.6   152.8  8771.6   149.2  8821.6   153.6
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
         4802.57  146.12 5059.19          151.44
Permanent Ineff=
       T       T
#Block Obstruct= 2 , 0
       0                    5875       0   147.1
Bank Sta=4961.8,5039
XS Rating Curve= 0
Vertical n Elevations= 2
   130.7  149.55
Vertical n for Station=1014.2
     .24     .24
Vertical n for Station=2152.5
     .48     .48
Vertical n for Station=3832.2
     .99     .99
Vertical n for Station=4961.8
     .04     .07
Vertical n for Station=5039
     .99     .99
Vertical n for Station=5648.1
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,195672  ,1073.8,1256,1261.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X65
END DESCRIPTION:
XS GIS Cut Line= 5
 3000920.310354813916494.1652965      3002851.42     13913652.77
      3002944.38     13912559.94       3002933.8     13912346.58
      3000704.11     13909624.01
#Sta/Elev= 30
     385   153.4    2195   147.9    2285     152    2885   151.4    3755   147.4
  3830.5   141.9  3910.5     151  4020.5   140.8  4070.5   146.6  4730.5   145.9
  4860.5   141.3  4890.5   144.5  4906.1  154.15  4956.6  145.23  4984.5  137.52
  4991.9  129.33  5009.3  131.93  5026.8  144.72  5087.9  152.55  5107.1  145.44
  5551.7     146  5656.7     134  5757.7     134  5782.7     140  5912.7     150
  6117.7     149  6277.7   141.1  6462.7     149    8650   150.4    8650  154.01
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
         4730.13  145.88  5087.7          152.47
Permanent Ineff=
       T       T
#Block Obstruct= 2 ,-1
  5551.7 5862.02   146.1 6128.73 6451.91   148.5
Bank Sta=4956.6,5026.8
XS Rating Curve= 0
Vertical n Elevations= 2
  129.33  149.27
Vertical n for Station=385
     .24     .24
Vertical n for Station=2124.7
     .48     .48
Vertical n for Station=3856.5
     .99     .99
Vertical n for Station=4956.6
     .04     .07
Vertical n for Station=5026.8
     .99     .99
Vertical n for Station=5659.8
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,194416  ,1004,341,365.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X64B
END DESCRIPTION:
XS GIS Cut Line= 4
     3002394.242     13916015.69      3004221.61     13912609.79
       3004139.8     13912303.03     3003407.666     13911421.75
#Sta/Elev= 30
   949.2   153.5  1869.2   151.7  2049.2   147.8  2139.2   151.3  3759.2   146.8
  3819.2   141.3  3929.2   151.1  4049.2   140.6  4169.2   145.8  4589.2   145.9
  4779.2   141.1  4799.2   142.5  4812.4   149.3  4875.8  143.12  4917.8  146.89
  4959.6  143.12  4975.9  140.41    4992  130.51  5050.7   141.9  5071.4  150.72
  5094.4   150.8  5171.8   144.2 5705.15     145 5795.15     134 5907.65     134
 5932.65     141 6042.65  151.75 6232.65     150 6277.65   150.5 6277.65   153.5
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
         4917.94  146.89 5071.44          150.71
Permanent Ineff=
       T       T
#Block Obstruct= 2 , 0
       0                  5611.8       0   145.9
Bank Sta=4959.6,5050.7
XS Rating Curve= 0
Vertical n Elevations= 2
  130.51  149.02
Vertical n for Station=949.2
     .24     .24
Vertical n for Station=1978.4
      .4      .4
Vertical n for Station=3946.3
     .99     .99
Vertical n for Station=4959.6
     .04     .07
Vertical n for Station=5050.7
     .99     .99
Vertical n for Station=5736.3
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,194075  ,647.9,689,714.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X64
END DESCRIPTION:
XS GIS Cut Line= 5
      3005550.89     13914736.65      3005325.94     13913591.42
      3004610.17     13912466.64      3004315.62      13912083.6
     3003750.272     13911239.86
#Sta/Elev= 30
    2270  154.01    2270   151.2    2310     151  3437.1   149.9  3547.1   148.6
  3607.1   143.5  4227.1   140.4  4247.1   145.2  4307.1   150.3  4357.1     146
  4387.1     140  4427.1   145.8  4974.3  144.29  4989.9  130.22  4996.1  129.76
  5009.6  130.36  5023.1  136.57  5024.1  141.92  5042.9  141.55  5085.5   151.7
  5140.3   144.9  5210.3   143.1  5663.5   145.3  5709.2     134  5986.7     134
  6016.7     141  6096.7     150  6256.7     150  6269.2   150.5  6269.2     153
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
         4934.13  145.91 5085.96          151.67
Permanent Ineff=
       T       T
#Block Obstruct= 3 ,-1
    3190 4306.41  150.03    4350 4427.18  145.81  5663.5    6054   145.3
Bank Sta=4974.3,5024.1
XS Rating Curve= 0
Vertical n Elevations= 2
  129.76  148.86
Vertical n for Station=2270
     .24     .24
Vertical n for Station=4297.7
     .99     .99
Vertical n for Station=4974.3
     .04     .07
Vertical n for Station=5024.1
     .99     .99
Vertical n for Station=5677.4
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,193386  ,909.5,1435,1215.7
BEGIN DESCRIPTION:
Cross Section XS62.5
END DESCRIPTION:
XS GIS Cut Line= 5
       3005503.6       13914363.      3005747.88     13913067.01
      3005069.85     13911962.98      3005005.32      13911854.1
     3004391.387     13911019.62
#Sta/Elev= 30
  2321.6  151.99  3421.6   149.9  3611.6   148.5  3740.4   142.6  4040.4   140.3
  4220.4   140.5  4250.4   145.3  4310.4   146.1  4380.4   139.5  4420.4   144.7
  4710.4     145  4770.4   141.1  4810.4     145    4936   145.4  4980.6  140.06
  4992.3  129.71  5000.9  129.16  5007.9   130.2  5026.2  145.21  5082.6   151.1
  5102.6   148.7  5122.6   142.6  5152.6   139.9  5222.6   144.3  5482.6   146.5
  5511.1     145  5571.1     134  5873.6     134  5958.6     150  6098.6     152
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
            4931  145.59  5082.7          151.03
Permanent Ineff=
       T       T
#Block Obstruct= 3 ,-1
    3611  4310.4   146.1    4308  4420.4   144.7  5412.6    5960   146.9
Bank Sta=4936,5026.2
XS Rating Curve= 0
Vertical n Elevations= 2
  129.16  148.59
Vertical n for Station=2321.6
     .24     .24
Vertical n for Station=4420.4
     .99     .99
Vertical n for Station=4947.3
     .04     .07
Vertical n for Station=5026.2
     .99     .99
Vertical n for Station=5532.6
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,191951  ,1570,1144,916.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X62
END DESCRIPTION:
XS GIS Cut Line= 4
      3005571.34     13914348.09      3006307.56     13911546.36
      3006348.46     13911362.31     3004295.721      13909776.1
#Sta/Elev= 30
  1986.6   151.3  3516.6   148.6  3666.6   142.7  4286.6   140.5  4386.6     146
  4486.6   144.8  4526.6   139.2  4576.6   143.4  4898.4  139.68  4912.3  145.98
  4947.3  142.94  4959.1  138.53  4980.6  138.82  4992.3  128.47  5000.9  127.92
  5007.9  128.96  5026.2  143.97  5046.6  144.92  5061.4  150.05    5112     150
    5192   144.3    5282   145.1  5381.2     136  5441.2     144  5908.7     146
  5983.7     134  6186.2     134  6211.2     141  6306.2     150  7666.2   150.6
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
         4911.62  145.95 5065.48          150.09
Permanent Ineff=
       T       T
#Block Obstruct= 4 ,-1
    3581  4386.7     146    4496  4576.4   143.4    5282    5600     144
  5908.7    6263     146
Bank Sta=4947.3,5026.2
XS Rating Curve= 0
Vertical n Elevations= 2
  127.92  148.09
Vertical n for Station=1986.6
     .24     .24
Vertical n for Station=4464.9
     .99     .99
Vertical n for Station=4947.3
     .04     .07
Vertical n for Station=5026.2
     .48     .48
Vertical n for Station=6070
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,190807  ,273.9,350,419.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X61
END DESCRIPTION:
XS GIS Cut Line= 5
      3009947.76     13917272.51      3008373.07     13912343.93
      3007378.88     13911179.47      3007169.75     13911070.04
     3004749.938     13909653.49
#Sta/Elev= 30
 -1754.7   154.7 -1664.7   151.1 -1524.7   152.8 -1504.7   150.4   985.3   149.5
  2715.3   151.8  3559.3     150  4469.3   141.5  4953.6  143.94  4984.5  132.27
  4990.6  127.48  5001.9  126.61  5009.5  128.38  5015.2  134.61  5030.2  140.84
  5060.8  143.51  5075.8  148.57  5122.5   143.6  5197.8  141.72  5813.9     144
  5905.9     134  5951.4     144  6001.4     146  6146.4     145  6237.4     139
  6267.4     134  6437.4     134  6500.4     146  6560.4     150  7990.4   150.5
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
         4944.02  145.04 5076.17          148.52
Permanent Ineff=
       T       T
#Block Obstruct= 2 ,-1
  5813.9    5951     144  6146.4    6500     145
Bank Sta=4953.6,5030.2
XS Rating Curve= 0
Vertical n Elevations= 2
  126.61  147.85
Vertical n for Station=-1754.7
     .24     .24
Vertical n for Station=4953.6
     .04     .07
Vertical n for Station=5030.2
     .48     .48
Vertical n for Station=6326.5
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,190457. ,94.7,95,84.2
BEGIN DESCRIPTION:
K100-00-00-S30_HOUSE-HAUL -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 5
      3010329.14      13917115.4      3008590.85     13912350.47
      3007684.46     13911086.33      3007554.87     13910843.13
     3006458.964      13910164.5
#Sta/Elev= 30
 -1782.1  154.55 -1732.1   155.6 -1702.1  152.14 -1622.1  150.49 -1572.1  152.23
 -1322.1  150.17  1427.9  149.25  2867.9   150.1  2947.9  151.68    3410  149.44
    3460  150.83    4510  141.69  4935.6  144.93 4979.35  137.62 4992.82  128.86
 4998.91  127.88 5006.24  128.46  5015.6  134.07  5035.6  139.81  5085.6  147.93
  5121.1   144.5  5311.1  142.46  5783.1     144  5832.1     139  5854.6     134
  6022.1     134  6041.1     139  6110.1     148  6250.1   151.5  6410.1   151.5
#Mann= 0 ,-1 , 0
#XS Ineff= 2 , 0
         4895.77  145.17 5086.28          147.94
Permanent Ineff=
       T       T
#Block Obstruct= 2 , 0
       0                  5783.1       0     144
Bank Sta=4935.6,5085.6
XS Rating Curve= 0
Vertical n Elevations= 2
  127.88  147.78
Vertical n for Station=-1782.1
     .24     .24
Vertical n for Station=4330
     .48     .48
Vertical n for Station=4935.6
     .04     .07
Vertical n for Station=5085.6
     .48     .48
Vertical n for Station=5811.1
     .24     .24
Vertical n Flow= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,190362  ,45.7,45,44.8
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
      3010412.78     13917070.84        3008674.     13912305.86
       3007768.1     13911041.72      3007638.51     13910798.53
     3006607.819     13910160.29
#Sta/Elev= 30
   -1778  154.66   -1748  155.26   -1718  152.46   -1668  152.56   -1638  150.26
   -1588  152.56   -1548  150.76      82  149.66  3394.1  150.76  4524.1  142.26
  4744.1  143.46  4764.1  141.56  4767.1  144.94  4772.4  145.57  4949.4  146.79
  4978.5  138.94    4992  129.35  4998.1  128.22  5006.2  128.71    5018  138.27
  5049.4  147.89  5242.2  145.66  5345.2  141.96  5745.2  145.76  5840.4     145
  5951.4     139  6017.4     141  6099.9     148  6197.4   150.5  6337.4     151
#Mann= 5 ,-1 , 0
   -1778     .06       0  4524.1      .1       0  4949.4     .07       0
  5049.4      .1       0  5745.2     .06       0
#XS Ineff= 2 , 0
       0 4921.81  147.62 5054.02       0  148.34
Permanent Ineff=
       F       F
#Block Obstruct= 2 , 0
       0                  5745.2       0  145.76
Bank Sta=4949.4,5049.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,190341  ,,,
BEGIN DESCRIPTION:
HOUSE-HAUL
Structure ID: K100-00-00-S30
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,22,2.6,0, 47, 47, , , .95, 0, ,,,
  4644.1  4767.1  4772.4    4777  4800.4  4801.9  4810.9    4857  4859.6  4921.8
    4947 4947.21  4947.3 4947.49  4947.6 4947.71 4947.99  4949.4  4949.5  4978.5
  4985.6    4992  4993.5  4993.7  4998.1  5005.5  5006.2  5006.8    5018  5042.2
  5042.3  5049.4 5049.79  5049.9 5050.01 5050.29  5050.4    5054  5092.2  5100.5
  5145.3  5150.8  5195.4  5201.4  5242.2  5247.7  5248.3
   142.1  144.99  145.62  145.64  145.86  145.91   146.2  147.33  147.39  148.59
  149.08  149.34  149.45  149.68  151.78  151.78  151.78  151.77  151.77  151.64
  151.61  151.58  151.57  151.57  151.55  151.52  151.52  151.51  151.46  151.35
  151.35  151.32  151.32  151.32  149.22  149.21  149.21  149.15  148.44  148.38
  147.11  147.01  146.21  146.06  145.71  145.41  145.39
                                                                                
                                                  148.52  148.51  148.51  148.38
  148.35  148.32  148.31  148.31  148.29  148.26  148.26  148.25   148.2  148.09
  148.09  148.06  148.06
                                                        
  4644.1  4767.1  4772.4    4777  4800.4  4801.9  4810.9    4857  4859.6  4921.8
    4947 4947.21  4947.3 4947.49  4947.6 4947.71 4947.99  4949.4  4949.5  4978.5
  4985.6    4992  4993.5  4993.7  4998.1  5005.5  5006.2  5006.8    5018  5042.2
  5042.3  5049.4 5049.79  5049.9 5050.01 5050.29  5050.4    5054  5092.2  5100.5
  5145.3  5150.8  5195.4  5201.4  5242.2  5247.7  5248.3
   142.1  144.99  145.62  145.64  145.86  145.91   146.2  147.33  147.39  148.59
  149.08  149.34  149.45  149.68  151.78  151.78  151.78  151.77  151.77  151.64
  151.61  151.58  151.57  151.57  151.55  151.52  151.52  151.51  151.46  151.35
  151.35  151.32  151.32  151.32  149.22  149.21  149.21  149.15  148.44  148.38
  147.11  147.01  146.21  146.06  145.71  145.41  145.39
                                                                                
                                                  148.52  148.51  148.51  148.38
  148.35  148.32  148.31  148.31  148.29  148.26  148.26  148.25   148.2  148.09
  148.09  148.06  148.06
                                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4964.9, 2 ,4964.9, 2 , 0 , 0 , 0 ,,
       1       1
  141.51  149.44
       1       1
  141.47   149.4
Pier Skew, UpSta & Num, DnSta & Num=  ,4981.8, 2 ,4981.8, 2 , 0 , 0 , 0 ,,
       1       1
   135.7  149.37
       1       1
  135.66  149.33
Pier Skew, UpSta & Num, DnSta & Num=  ,4999.5, 2 ,4999.5, 2 , 0 , 0 , 0 ,,
       1       1
   127.3  149.29
       1       1
  127.26  149.25
Pier Skew, UpSta & Num, DnSta & Num=  ,5015.9, 2 ,5015.9, 2 , 0 , 0 , 0 ,,
       1       1
  135.22  149.21
       1       1
  135.18  149.17
Pier Skew, UpSta & Num, DnSta & Num=  ,5032.9, 2 ,5032.9, 2 , 0 , 0 , 0 ,,
       1       1
  142.46  149.13
       1       1
  142.42  149.09
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=155.26

Type RM Length L Ch R = 1 ,190317  ,105.2,106,95.8
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
      3010451.99      13917048.9      3008712.75     13912281.36
      3007805.54     13911016.07      3007674.04     13910769.28
       3003960.9     13908469.98
#Sta/Elev= 30
   -1778  154.64   -1748  155.24   -1718  152.44   -1668  152.54   -1638  150.24
   -1588  152.54   -1548  150.74      82  149.64  3394.1  150.74  4524.1  142.24
  4744.1  143.44  4764.1  141.54  4767.1  144.92  4772.4  145.55  4949.4  146.77
  4978.5  138.92    4992  129.33  4998.1   128.2  5006.2  128.69    5018  138.25
  5042.2  146.91  5049.4  147.87  5242.2  145.64  5345.2  141.94  5745.2  145.74
  6775.2  148.04  6865.2  146.44  7035.2  149.24  7515.2  148.14  9487.2  149.84
#Mann= 5 ,-1 , 0
   -1778     .12       0  4524.1      .2       0  4949.4   .0525       0
  5049.4      .2       0  5745.2     .12       0
#XS Ineff= 2 , 0
       0 4942.73   141.8 5056.07       0   144.6
Permanent Ineff=
       F       F
Bank Sta=4949.4,5049.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,190211. ,541.1,647,497.4
BEGIN DESCRIPTION:
K100-00-00-S30_HOUSE-HAUL -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 5
      3010540.31      13916992.9      3008801.07     13912225.38
      3007893.86     13910960.09      3007762.36     13910713.31
      3004049.23       13908414.
#Sta/Elev= 30
 -1780.9  155.14 -1670.9  150.37 -1570.9  149.86  -460.9  149.72  -390.9  151.69
   219.1  149.39    3504  150.41    4094  143.72    4594  142.01    4664  144.41
    4694  141.42    4724  143.94    4754  141.62    4794  142.64    4824  145.03
  4850.9   150.5  4890.9  150.24  4940.9  145.15 4998.69  127.94  5100.9  144.27
  5200.5  142.81  5220.5   139.3  5260.5  144.81  5340.5  142.02  5800.5  146.15
  6740.5  147.56  6800.5  144.09  6880.5  147.99  7150.5  148.81  9497.9  149.33
#Mann= 5 ,-1 , 0
 -1780.9     .12       0    4794     .24       0  4890.9     .06       0
  5100.9     .24       0  5200.5     .12       0
Bank Sta=4890.9,5100.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,189564  ,1415.4,1581,2260.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X60
END DESCRIPTION:
XS GIS Cut Line= 4
      3010847.58     13916924.85      3008413.97     13910605.64
      3008239.48     13910307.83      3004569.27     13908662.84
#Sta/Elev= 30
 -1996.5   154.2 -1506.5   149.6  1913.5   148.7  3053.5   150.8  3883.5   144.3
  4463.5   143.2  4493.5   140.9  4937.7  143.11  4948.7  140.16  4979.8  139.71
  4986.2  135.69    4991  127.84  5002.3  126.35  5008.4  127.51  5025.8  140.61
  5074.6  148.23  5120.3   140.6  5230.3   142.6  5330.3   140.5  5620.3   145.2
  5700.3   141.9  5740.3   146.9  5760.3   144.6  5821.8   144.9  6090.3   144.6
  6160.3   147.3  6240.3   143.3  6270.3     146  7090.3   148.2  9142.3   150.1
#Mann= 5 ,-1 , 0
 -1996.5     .12       0  4937.7      .2       0  4979.8    .075       0
  5025.8     .24       0  5821.8     .12       0
Bank Sta=4979.8,5025.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,187983  ,1044,1046,1023.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X59
END DESCRIPTION:
XS GIS Cut Line= 4
      3011092.99     13916883.95      3009784.15     13910298.88
       3009559.2     13909194.55      3008291.26     13903222.99
#Sta/Elev= 30
 -2250.4   153.5 -2180.3   154.9 -2010.3   149.8  1049.7   147.3  1099.7   151.5
  3239.7   148.5  3879.7   142.5  3909.7   144.9  4109.7   139.5  4459.7   148.2
  4523.6   142.1  4673.6   136.8  4733.6   142.1  4843.6   142.9  4903.8  151.16
  4928.9  145.11  4978.1  139.33  4986.1  128.02  4997.9  125.88  5013.1  127.36
  5020.8  138.13  5054.1  143.45  5193.6   138.6  5313.6   142.5  5760.6     143
  6030.6   140.9  6080.6     137  6160.6   143.9  6360.6   147.5 11695.3   150.2
#Mann= 5 ,-1 , 0
 -2250.4     .12       0  4928.9      .2       0  4978.1    .075       0
  5020.8     .24       0  6360.6     .12       0
Bank Sta=4978.1,5020.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,186937  ,1189,1224,1201.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X58
END DESCRIPTION:
XS GIS Cut Line= 4
      3011829.21       13916659.      3010827.13     13910196.63
      3010643.08      13909296.8      3008884.33     13903100.29
#Sta/Elev= 30
 -2148.4   153.3  1461.6   147.5  1811.6   151.4  2171.6   147.1  2571.6   151.9
  2731.6   147.1  2801.6   152.6  3051.6   155.3  3681.6   142.9  3781.6   148.7
  4081.6   145.6  4291.6   149.2  4371.6   138.8  4511.2   145.3  4671.2   136.2
  4731.2   142.5  4935.3  142.46  4964.7  138.15    4997  125.12  5038.5   141.6
  5141.2   140.8  5171.2   135.1  5201.2   144.6  5499.7   138.1  5559.7   144.3
    6043   143.5  6429.7   138.7  6789.7   150.6  6899.7   147.2 11750.9   149.9
#Mann= 5 ,-1 , 0
 -2148.4     .12       0  4671.2     .24       0  4935.3    .075       0
  5038.5     .24       0    6043     .12       0
#Block Obstruct= 2 ,-1
    3468    4270   147.3    5000  5000.1      50
Bank Sta=4935.3,5038.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,185713  ,290.9,225,222.2
BEGIN DESCRIPTION:
Cross Section Xs57.2
END DESCRIPTION:
XS GIS Cut Line= 5
      3012020.36      13916624.9      3011933.59     13909543.16
       3011901.2     13909348.83      3011881.27     13909235.53
      3009989.93     13903076.06
#Sta/Elev= 30
 -2198.3     153 -2048.3   147.8 -1508.3   152.3   661.7     148  2231.7   147.8
  2271.7   143.6  2561.7   147.9  2661.7   143.8  2751.7   148.8  4051.7   144.2
  4201.7   147.7  4611.7   139.6  4711.7   144.5  4801.7     142  4935.3  142.72
  4964.7  138.41    4997  125.38  5038.5  141.86    5101   143.9    5191   134.5
  5206.1   139.3  5446.1   145.5  5576.1   140.6  5726.1     146  6256.1   141.2
  6446.1     146  6676.1   138.5  6796.1   146.7  7446.1   148.9 11639.4   148.5
#Mann= 7 ,-1 , 0
 -2198.3     .12       0   661.7      .2       0  2231.7     .12       0
  4801.7     .24       0  4935.3     .06       0  5038.5     .24       0
  5206.1     .12       0
#XS Ineff= 2 , 0
       0 4276.82   147.8 5813.15       0   147.8
Permanent Ineff=
       F       F
Bank Sta=4935.3,5038.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,185488. ,246.9,210,205.5
BEGIN DESCRIPTION:
K100-00-00-S29_FRY RD -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3012159.19      13916572.9      3012152.91     13909502.38
      3012110.89      13909245.6      3010246.12      13902992.4
#Sta/Elev= 30
 -2188.7   153.8 -2058.7  147.35 -1708.7  151.43   581.3  147.13   641.3  151.19
   691.3  147.83  1051.3  149.17  2201.3  147.88  2421.3  147.81  2491.3   152.7
  2541.3  146.83  3371.3  150.22  3931.3  146.76  4021.3  150.98  4201.3  144.82
  4331.3  146.88  4391.3  141.66  4451.3  146.23  4611.3  138.77  4821.3  141.08
  4911.8  140.68  5001.6  125.43 5023.24  126.95  5071.8  140.32    5172  143.13
    5822  138.07    6592  138.31    6812  146.57    7502  148.77 11667.4  148.36
#Mann= 8 ,-1 , 0
 -2188.7     .99       0   641.3     .12       0  1051.3      .2       0
  2201.3     .12       0  4821.3     .24       0  4911.8     .06       0
  5071.8     .24       0    5172     .12       0
#XS Ineff= 2 , 0
         4460.21   147.9 5393.22          147.78
Permanent Ineff=
       F       F
Bank Sta=4911.8,5071.8
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,185278  ,54.7,56,55.5
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3012274.37     13916596.08      3012361.06       13909486.
      3012319.04     13909229.21      3010454.28     13902976.02
#Sta/Elev= 30
 -2247.9  155.09 -2167.9  154.89 -2127.9  149.19 -2057.9  147.89 -1637.9  150.99
   542.1  146.89   602.1  151.39   662.1  147.89  2512.1  146.79  2742.1  150.39
  2782.1  146.29  3272.1  148.99  3602.1  144.49  3712.1  148.39  3882.1  144.09
  4272.1  148.89  4302.1  145.19  4402.1  146.79    4620  141.87  4892.7  141.99
  4964.7  126.45  5005.9  125.47  5042.6  127.48  5090.5  140.25  5282.9  140.59
  5452.9  140.89  6792.9  142.89  7012.9  147.19  7622.9  149.29 11648.2  148.09
#Mann= 6 ,-1 , 0
 -2247.9     .12       0    4620     .24       0  4892.7     .06       0
  5090.5     .16       0  5282.9     .24       0  5452.9     .12       0
#XS Ineff= 2 , 0
       0 4885.81   147.8 5301.04       0   147.8
Permanent Ineff=
       F       F
Bank Sta=4892.7,5090.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,185251.5,,,
BEGIN DESCRIPTION:
FRY RD.  (NEW RD NOT ON SIDS)
Structure ID: K100-00-00-S29
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,33,2.6,0, 60, 60, , , .95, 0, ,,,
 -2247.9 -2217.9 -2167.9 -2117.9 -2057.9 -1987.9 -1697.9 -1637.9 -1567.9 -1487.9
   522.1   542.1   602.1   662.1   702.1   882.1  1602.1  1772.1  1992.1  2102.1
  2512.1  2742.1  2782.1  2832.1  3052.1  3102.1  3272.1  3352.1  3552.1  3602.1
  3712.1  3882.1  3912.1  4172.1  4272.1  4312.1  4402.1  4572.1  4732.1 4820.49
  4820.6  4852.1  4893.8  4893.9  5108.4 5283.89    5284  5354.5 5354.61  5532.9
  6412.9  6712.9  6792.9  7012.9  7462.9  7622.9  7852.9 10732.9 10832.9 11648.2
   155.1   155.6   154.9   148.6   147.9   150.4   148.7     151   148.5   150.4
   149.2   146.9   151.4   147.9   150.1   150.1   146.9   149.1     147   149.4
   146.8   150.4   146.3   148.3   146.7   149.2     149   146.9  148.46  148.49
  148.56  148.66  148.68  148.84   148.9  148.97  149.11   149.4  149.66  149.95
  152.75  152.79  152.89  152.89  153.42  152.91  152.91  152.72  149.92  149.05
  148.17  147.87  147.79  147.57   146.8   149.3   147.4   149.7   147.8   148.1
  155.09  155.59  154.89  148.59  147.89  150.39  148.69  150.99  148.49  150.39
  149.19  146.89  151.39  147.89  150.09  150.09  146.89  149.09  146.99  149.39
  146.79  150.39  146.29  148.29  146.69  149.19  148.99  146.89  146.89  144.49
  148.39  144.09  146.59  145.19  148.89  144.99  146.79  141.19  140.39  141.45
  141.45  144.29  141.78  147.08  147.61   147.1   140.6  140.53  140.53  140.29
  141.89  145.29  142.89  147.19  146.79  149.29  147.39  149.69  147.79  148.09
 -2247.9 -2217.9 -2167.9 -2117.9 -2057.9 -1987.9 -1697.9 -1637.9 -1567.9 -1487.9
   522.1   542.1   602.1   662.1   702.1   882.1  1602.1  1772.1  1992.1  2102.1
  2512.1  2742.1  2782.1  2832.1  3052.1  3102.1  3272.1  3352.1  3552.1  3602.1
  3712.1  3882.1  3912.1  4172.1  4272.1  4312.1  4402.1  4572.1  4732.1 4820.49
  4820.6  4852.1  4893.8  4893.9  5108.4 5283.89    5284  5354.5 5354.61  5532.9
  6412.9  6712.9  6792.9  7012.9  7462.9  7622.9  7852.9 10732.9 10832.9 11648.2
   155.1   155.6   154.9   148.6   147.9   150.4   148.7     151   148.5   150.4
   149.2   146.9   151.4   147.9   150.1   150.1   146.9   149.1     147   149.4
   146.8   150.4   146.3   148.3   146.7   149.2     149   146.9  148.46  148.49
  148.56  148.66  148.68  148.84   148.9  148.97  149.11   149.4  149.66  149.95
  152.75  152.79  152.89  152.89  153.42  152.91  152.91  152.72  149.92  149.05
  148.17  147.87  147.79  147.57   146.8   149.3   147.4   149.7   147.8   148.1
  155.09  155.59  154.89  148.59  147.89  150.39  148.69  150.99  148.49  150.39
  149.19  146.89  151.39  147.89  150.09  150.09  146.89  149.09  146.99  149.39
  146.79  150.39  146.29  148.29  146.69  149.19  148.99  146.89  146.89  144.49
  148.39  144.09  146.59  145.19  148.89  144.99  146.79  141.19  140.39  141.45
  141.45  144.29  141.78  147.08  147.61   147.1   140.6  140.53  140.53  140.29
  141.89  145.29  142.89  147.19  146.79  149.29  147.39  149.69  147.79  148.09
Pier Skew, UpSta & Num, DnSta & Num=  ,4963.7, 2 ,4963.7, 2 , 0 , 0 , 0 ,,
       3       3
  125.44   148.3
       3       3
  126.18  149.04
Pier Skew, UpSta & Num, DnSta & Num=  ,5034, 2 ,5034, 2 , 0 , 0 , 0 ,,
       3       3
  125.47  148.52
       3       3
  126.21  149.26
Pier Skew, UpSta & Num, DnSta & Num=  ,5104.6, 2 ,5104.6, 2 , 0 , 0 , 0 ,,
     1.7     1.7
  139.41  148.61
     1.7     1.7
  140.15  149.35
Pier Skew, UpSta & Num, DnSta & Num=  ,5164.3, 2 ,5164.3, 2 , 0 , 0 , 0 ,,
     1.7     1.7
  139.31  148.46
     1.7     1.7
  140.05   149.2
Pier Skew, UpSta & Num, DnSta & Num=  ,5224.1, 2 ,5224.1, 2 , 0 , 0 , 0 ,,
     1.7     1.7
  139.57  148.26
     1.7     1.7
  140.31     149
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=155.59

Type RM Length L Ch R = 1 ,185222  ,229.6,194,190.7
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3012327.67     13916585.01      3012414.38     13909473.19
      3012371.87     13909213.41      3010506.74     13902958.99
#Sta/Elev= 30
 -2247.9  155.81 -2167.9  155.61 -2127.9  149.91 -2057.9  148.61 -1637.9  151.71
   542.1  147.61   602.1  152.11   662.1  148.61  2512.1  147.51  2742.1  151.11
  2782.1  147.01  3272.1  149.71  3602.1  145.21  3712.1  149.11  3882.1  144.81
  4272.1  149.61  4302.1  145.91  4402.1  147.51    4620  142.59  4892.7  142.71
  4964.7  127.17  5005.9  126.19  5042.6   128.2  5090.5  140.97  5282.9  141.31
  5452.9  141.61  6792.9  143.61  7012.9  147.91  7622.9  150.01 11648.2  148.81
#Mann= 6 ,-1 , 0
 -2247.9     .12       0    4620     .24       0  4892.7     .06       0
  5090.5     .16       0  5282.9     .24       0  5452.9     .12       0
#XS Ineff= 2 , 0
       0 4871.97   147.8 5289.57       0   147.8
Permanent Ineff=
       F       F
Bank Sta=4892.7,5090.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,185028. ,323.3,275,270.5
BEGIN DESCRIPTION:
K100-00-00-S29_FRY RD -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3012519.81      13916566.3      3012606.52     13909454.57
      3012564.01      13909194.8      3010698.88     13902940.37
#Sta/Elev= 30
 -2246.2  159.41 -2136.2   161.1 -2086.2  149.28 -2016.2  147.41 -1486.2  150.77
   453.8  147.18   583.8   151.5  2503.8  148.62  3343.8  142.74  3393.8  146.45
  3433.8  142.54  4383.8  141.54  4423.8  145.14  4633.8  137.12  4693.8   146.6
  4813.8  139.76  4886.2  140.99  4916.2  146.68  4976.2  137.64  4988.9  126.93
  5004.2  125.89 5030.79  128.58  5056.2  140.85  5159.4  136.97  5259.4   143.3
  5449.4  140.07  5509.4  145.83  5599.4  138.87  7629.4  148.62   11656  147.81
#Mann= 6 ,-1 , 0
 -2246.2     .99       0  2503.8     .12       0  4813.8     .24       0
  4916.2    .075       0  5056.2     .24       0  5159.4     .12       0
#XS Ineff= 2 , 0
          4447.6   147.35500.422        147.6345
Permanent Ineff=
       F       F
Bank Sta=4916.2,5056.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,184753  ,966.7,926,919
BEGIN DESCRIPTION:
Cross Section Xs57.1
END DESCRIPTION:
XS GIS Cut Line= 5
      3012696.72      13916542.7      3012892.23     13909574.05
      3012870.17     13909361.26      3012843.41     13909206.05
      3011067.32     13903089.21
#Sta/Elev= 30
 -2268.6   159.3 -2238.6   164.8 -2138.6   165.1 -2078.6   149.8 -2018.6   147.5
 -1438.6   147.1 -1358.6   150.5   401.4     150   431.4   146.9   551.4   151.1
  2611.4   148.5  3581.4   147.4  3871.4   141.7  4361.4   143.7  4461.4   137.5
  4661.4   137.1  4752.8   142.3  4882.8   140.9  4912.8   143.6  4976.8   136.7
  4984.6  134.84  4989.3  126.87  5001.8  125.47  5046.8   139.2  5094.3   142.5
  5284.3   134.9  5324.3   139.9  5434.3   140.1  7744.3   147.2 11443.7   147.9
#Mann= 9 ,-1 , 0
 -2268.6     .99       0  2611.4     .12       0  4361.4     .05       0
  4752.8     .12       0  4882.8     .24       0  4912.8    .075       0
  5094.3     .24       0  5434.3     .12       0  7744.3     .99       0
#XS Ineff= 2 , 0
       0  4373.7   147.4 5799.31       0   147.4
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
    4359  4752.8   142.3    5093 5524.26   142.2
Bank Sta=4912.8,5094.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,183827  ,1111.6,1459,1403
BEGIN DESCRIPTION:
Cross Section K100-00-00-X57
END DESCRIPTION:
XS GIS Cut Line= 4
       3013403.9     13916270.44      3013833.36     13909460.41
      3013731.11     13908969.59      3011890.56     13903038.94
#Sta/Elev= 30
   -2194   158.9   -2154   161.2   -2104   150.3   -2074   147.6   -1724   150.4
   -1684     146   -1644   148.4    -934   147.9    -874   150.6    -814   147.4
    2746   147.8    3166   143.5  4276.8   140.4    4416   140.8    4546   146.8
    4566   145.7    4596   137.6  4709.6   137.5  4922.6  143.98  4984.6  133.44
  4989.3  125.47  5001.8  124.07    5012  125.95  5024.6  137.91    5040  137.05
  5066.3   142.3  5130.9   139.8  5572.7  140.84  7680.9   145.7 11340.6   147.3
#Mann= 7 ,-1 , 0
   -2194     .99       0    2746     .12       0  4276.8     .24       0
  4984.6    .075       0  5024.6     .24       0  5572.7     .12       0
  7680.9     .99       0
Bank Sta=4984.6,5024.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,182368  ,573.73,703.97,1073.36
BEGIN DESCRIPTION:
Cross Section K100-00-00-X56
END DESCRIPTION:
XS GIS Cut Line= 4
      3013757.69     13916157.96      3015001.09     13908583.08
      3014984.73     13908239.51      3012933.54     13903079.84
#Sta/Elev= 30
 -2853.9   163.9 -2783.8   147.4 -2713.8   150.6 -2593.8   150.9 -2473.8   150.7
 -2433.8   146.3 -1443.8   148.1 -1283.8   148.6 -1233.8   151.9 -1143.8   148.2
  -943.8   146.8   606.2   147.7 3670.89   139.8 4052.21  137.32 4241.92   139.5
  4842.5     140  4892.5   144.1  4946.5  140.07  4959.3  134.83  4979.7  135.29
  4993.5  124.26  4999.4  123.91  5007.8  124.27  5013.7  132.32  5021.7  137.22
  5092.5   139.9  5556.4   138.1  6586.4     144  7386.4   143.6 10718.8   144.4
#Mann= 7 ,-1 , 0
 -2853.9     .99       0   606.2     .24       0 3670.89     .04       0
 4241.92     .24       0  4979.7    .075       0  5021.7     .24       0
  7386.4     .99       0
#Block Obstruct= 1 ,-1
 3724.86 4216.16   138.3
Bank Sta=4979.7,5021.7
XS Rating Curve= 0
Exp/Cntr=.3,.1
