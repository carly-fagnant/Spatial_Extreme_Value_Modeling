HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 3 ,32175   ,,,
BEGIN DESCRIPTION:
ALDINE WESTFIELD
Structure ID: K100-00-00-S4
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,60,2.6,0, 154, 154, , , .95, 0, ,,,
  4346.7  4442.6  4456.7  4496.7  4506.7  4522.6  4536.7  4546.7  4556.7  4566.7
  4586.7  4596.7  4616.7  4622.6  4626.7 4630.89    4631 4631.11  4634.2    4650
  4689.9  4695.1  4728.2  4743.8  4772.7  4796.1  4830.6  4843.4 4843.51 4843.63
  4843.7  4869.1  4877.3  4897.9    4915  4915.1  4922.1  4939.8    4948  4953.1
  4958.1  4966.5  4978.4  4978.5  4981.8  4986.3  4990.2  4997.9  5008.5  5021.4
  5025.7  5031.2  5057.8  5058.1  5061.8  5067.7  5102.6    5103  5129.1  5129.3
  5163.8  5171.1  5200.4  5200.6  5238.1  5238.6  5272.1  5272.3  5311.4  5313.3
    5342  5343.1 5343.17 5343.29  5343.4  5343.5  5359.6  5376.8  5429.6  5458.9
  5490.6  5516.1    5550  5569.9 5569.99  5570.1 5570.21  5570.5  5570.6  5603.2
  5627.3  5637.3  5687.3  5768.1  5817.3  5837.3  5867.3  5907.3  5917.3  5937.3
  5957.3  5977.3  6017.3  6157.3  6237.3  6247.3  6267.3  6277.3  6307.3  6317.3
  6327.3  6337.3  6347.3  6507.3  6657.3  6687.3  6727.3  6787.3  6807.3  6837.3
  6847.3  6987.3  7017.3  7107.3  7137.3  7287.3  7327.3  7387.3  7607.3  7617.3
  7647.3  7667.3  7687.3  7707.3  7847.3  7917.3  7937.3  8317.3  8347.3  8407.3
  8437.3  8457.3  8497.3  8727.3  8747.3  8787.3  8797.3  8827.3  8847.3  8857.3
  8877.3  9087.3  9147.3  9435.7
    95.2   92.45   92.17   91.38   91.19   90.87   90.59    90.4    90.2      90
   89.61   89.41   89.02    88.9   89.18   89.46   92.26   92.26   92.26   92.09
   91.67   91.66   91.59   91.56   91.64    91.7   91.71   91.72   91.72   91.72
   91.72    91.8   91.82   91.82   91.82   91.82   91.82   91.82   91.82   91.82
   91.82   91.82   91.82   91.82   91.82   91.82   91.83   91.85   91.87    91.9
   91.91   91.91   91.89   91.89   91.89   91.88   91.86   91.86   91.86   91.86
   91.85   91.85   91.87   91.87    91.9    91.9   91.81   91.81   91.81   91.81
   91.81   91.81   91.81   91.81   91.81   91.81   91.78   91.77   91.74   91.73
   91.45   91.22   90.82   90.59   90.48   90.48   87.68   87.43   87.84   86.63
   85.73   85.36    83.5   80.73    80.8    80.4    80.9    80.4      80      78
    77.8    78.7    78.8    79.3    79.9    80.5    82.4      83    82.9    82.6
    81.6    81.1    81.7    82.1    82.6    83.1    82.9    81.6      82    81.9
    82.2    81.5      82    81.5    82.1    81.3    81.9    80.7      84    83.8
    84.1    83.8    83.9    83.6    85.3    85.1    85.7    86.1    85.2    86.4
      86    86.8    86.7      88    88.8    88.6    88.9    88.6    88.9    88.5
      89    92.3    92.4      95
                                                                                
                                                                                
                                                                                
   83.62    83.7   83.72   83.72   83.72   83.72   83.72   83.72   83.72   83.72
   83.72   83.72   83.72   83.72   83.72   83.72   83.73   83.75   83.77    83.8
   83.81   83.81   83.79   83.79   83.79   83.78   83.76   83.76   83.76   83.76
   83.75   83.75   83.77   83.77    83.8    83.8   83.71   83.71   83.71   83.71
   83.71   83.71
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                
  4346.7  4442.6  4456.7  4496.7  4506.7  4522.6  4536.7  4546.7  4556.7  4566.7
  4586.7  4596.7  4616.7  4622.6  4626.7 4630.89    4631 4631.11  4634.2    4650
  4689.9  4695.1  4728.2  4743.8  4772.7  4796.1  4830.6  4843.4 4843.51 4843.63
  4843.7  4869.1  4877.3  4897.9    4915  4915.1  4922.1  4939.8    4948  4953.1
  4958.1  4966.5  4978.4  4978.5  4981.8  4986.3  4990.2  4997.9  5008.5  5021.4
  5025.7  5031.2  5057.8  5058.1  5061.8  5067.7  5102.6    5103  5129.1  5129.3
  5163.8  5171.1  5200.4  5200.6  5238.1  5238.6  5272.1  5272.3  5311.4  5313.3
    5342  5343.1 5343.17 5343.29  5343.4  5343.5  5359.6  5376.8  5429.6  5458.9
  5490.6  5516.1    5550  5569.9 5569.99  5570.1 5570.21  5570.5  5570.6  5603.2
  5627.3  5637.3  5687.3  5768.1  5817.3  5837.3  5867.3  5907.3  5917.3  5937.3
  5957.3  5977.3  6017.3  6157.3  6237.3  6247.3  6267.3  6277.3  6307.3  6317.3
  6327.3  6337.3  6347.3  6507.3  6657.3  6687.3  6727.3  6787.3  6807.3  6837.3
  6847.3  6987.3  7017.3  7107.3  7137.3  7287.3  7327.3  7387.3  7607.3  7617.3
  7647.3  7667.3  7687.3  7707.3  7847.3  7917.3  7937.3  8317.3  8347.3  8407.3
  8437.3  8457.3  8497.3  8727.3  8747.3  8787.3  8797.3  8827.3  8847.3  8857.3
  8877.3  9087.3  9147.3  9435.7
    95.2   92.45   92.17   91.38   91.19   90.87   90.59    90.4    90.2      90
   89.61   89.41   89.02    88.9   89.18   89.46   92.26   92.26   92.26   92.09
   91.67   91.66   91.59   91.56   91.64    91.7   91.71   91.72   91.72   91.72
   91.72    91.8   91.82   91.82   91.82   91.82   91.82   91.82   91.82   91.82
   91.82   91.82   91.82   91.82   91.82   91.82   91.83   91.85   91.87    91.9
   91.91   91.91   91.89   91.89   91.89   91.88   91.86   91.86   91.86   91.86
   91.85   91.85   91.87   91.87    91.9    91.9   91.81   91.81   91.81   91.81
   91.81   91.81   91.81   91.81   91.81   91.81   91.78   91.77   91.74   91.73
   91.45   91.22   90.82   90.59   90.48   90.48   87.68   87.43   87.84   86.63
   85.73   85.36    83.5   80.73    80.8    80.4    80.9    80.4      80      78
    77.8    78.7    78.8    79.3    79.9    80.5    82.4      83    82.9    82.6
    81.6    81.1    81.7    82.1    82.6    83.1    82.9    81.6      82    81.9
    82.2    81.5      82    81.5    82.1    81.3    81.9    80.7      84    83.8
    84.1    83.8    83.9    83.6    85.3    85.1    85.7    86.1    85.2    86.4
      86    86.8    86.7      88    88.8    88.6    88.9    88.6    88.9    88.5
      89    92.3    92.4      95
                                                                                
                                                                                
                                                                                
   83.62    83.7   83.72   83.72   83.72   83.72   83.72   83.72   83.72   83.72
   83.72   83.72   83.72   83.72   83.72   83.72   83.73   83.75   83.77    83.8
   83.81   83.81   83.79   83.79   83.79   83.78   83.76   83.76   83.76   83.76
   83.75   83.75   83.77   83.77    83.8    83.8   83.71   83.71   83.71   83.71
   83.71   83.71
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4915.1, 2 ,4915.1, 2 , 0 , 0 , 0 ,,
       3       3
   72.93   84.72
       3       3
   73.84   85.63
Pier Skew, UpSta & Num, DnSta & Num=  ,4986.1, 2 ,4986.1, 2 , 0 , 0 , 0 ,,
       3       3
   50.39   84.72
       3       3
    51.3   85.63
Pier Skew, UpSta & Num, DnSta & Num=  ,5058.1, 2 ,5058.1, 2 , 0 , 0 , 0 ,,
       3       3
   66.13   84.79
       3       3
   67.04    85.7
Pier Skew, UpSta & Num, DnSta & Num=  ,5129.3, 2 ,5129.3, 2 , 0 , 0 , 0 ,,
       3       3
   72.47   84.76
       3       3
   73.38   85.67
Pier Skew, UpSta & Num, DnSta & Num=  ,5200.4, 2 ,5200.4, 2 , 0 , 0 , 0 ,,
       3       3
   74.22   84.77
       3       3
   75.13   85.68
Pier Skew, UpSta & Num, DnSta & Num=  ,5272.3, 2 ,5272.3, 2 , 0 , 0 , 0 ,,
       3       3
   76.23   84.71
       3       3
   77.14   85.62
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=95.2

Type RM Length L Ch R = 1 ,32130   ,51.3,49,38.1
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
      3112812.86      13944190.6      3113113.38     13943037.21
      3113614.98     13939169.95
#Sta/Elev= 30
  4346.7   95.92  4456.7   92.32  4522.6   87.88  4626.7   82.32    4650   83.13
  4922.1   74.59  4978.4   53.51  4997.9   51.49  5021.4   53.45  5031.2   56.44
  5061.8   70.77    5103   73.44  5272.3      78  5687.3   81.32  5867.3   81.62
  5957.3   78.52  6237.3   80.62  6277.3   83.72  6337.3   81.82  6687.3   83.82
  6787.3   82.32  7327.3   82.62  7387.3   81.42  7607.3   84.72  7847.3   86.02
  8347.3   85.92  8747.3   89.52  8857.3   89.22  9087.3   93.02  9435.7   95.72
#Mann= 4 , 1 , 0
  4346.7     .99       0  4522.6      .1       0  4922.1    .055       0
  5061.8     .14       0
#XS Ineff= 2 , 0
       0    4831    87.7 5359.38       0      83
Permanent Ineff=
       F       F
Bank Sta=4922.1,5061.8
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,32081   ,25.2,25,25
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
      3112856.35      13944292.2      3113102.82     13943236.12
      3113718.12     13939194.09
#Sta/Elev= 30
  4253.7   96.99  4423.8   95.99  4533.7   86.19  4563.7   84.99  4653.8   85.49
 4920.69   80.91 4925.39   79.14 4947.29   66.26 4978.59   52.45 4993.99   50.43
 5023.99   51.76 5040.29   56.93 5044.69    62.2 5052.29    64.4 5085.29   69.75
 5098.59   79.09 5311.39   77.47  5438.3   77.99  5468.2   79.09  6088.3   78.79
  6248.2   82.59  6318.3   82.49  6358.2   80.39  6428.2   80.19  6758.2   82.49
  7378.3   80.49  7798.2   85.09  8562.3   87.71  8978.3   89.99  9426.9   94.49
#Mann= 4 ,-1 , 0
  4253.7      .1       0 4920.69    .055       0 5098.59     .14       0
  8562.3    .055       0
#XS Ineff= 2 , 0
       0 4849.61    86.4 5207.03       0      83
Permanent Ineff=
       F       F
Bank Sta=4920.69,5098.59
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,32070   ,,,
BEGIN DESCRIPTION:
PL1_K100-00-00-S3
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,2,2.6,0, 152, 152, , , .95, 0, ,,,
  4253.7  4253.8  4283.7  4283.8  4413.7  4413.8  4423.7  4423.8  4453.7  4453.8
  4473.7  4473.8  4483.7  4483.8  4503.7  4503.8  4533.7  4533.8  4563.7  4563.8
  4573.7  4573.8  4613.7  4613.8  4643.7  4643.8  4653.7  4653.8  4673.7  4673.8
 4695.79  4713.8 4754.39 4801.09 4861.39 4902.49  4903.7  4913.7 4920.69  4923.7
 4925.39 4926.39  4926.5 4926.59 4947.29 4963.19 4969.69 4978.59 4981.39 4993.99
 5006.39 5017.09 5021.39 5023.99 5040.29 5044.69 5052.29 5062.69 5085.29 5098.59
 5106.38 5106.49 5106.59  5113.7  5123.7 5152.59  5163.7  5183.8 5205.49  5243.8
 5259.89  5273.7  5303.8 5311.39  5323.8  5338.2 5355.49  5438.2  5438.3  5468.2
  5468.3  5668.2  5668.3  5748.2  5748.3  6088.2  6088.3  6218.2  6218.3  6248.2
  6248.3  6278.2  6278.3  6288.2  6288.3  6318.2  6318.3  6358.2  6358.3  6428.2
  6428.3  6438.2  6438.3  6528.2  6528.3  6548.2  6548.3  6608.2  6608.3  6668.2
  6668.3  6728.2  6728.3  6758.2  6758.3  6848.2  6848.3  6938.2  6938.3  6958.2
  6958.3  7008.2  7008.3  7258.2  7258.3  7378.2  7378.3  7548.2  7548.3  7638.2
  7638.3  7798.2  7798.3  7898.2  7898.3  8048.2  8048.3  8562.3  8728.2  8728.3
  8748.2  8748.3  8778.2  8778.3  8795.8  8808.2  8808.3  8861.8  8978.2  8978.3
  9426.8  9426.9
    96.8    96.8    95.9    95.9    96.1    96.1    95.8   95.81   93.51    93.5
   91.31    91.3      91      91   88.41    88.4   86.01      86    84.8    84.8
    85.1    85.1    84.4    84.4    85.4    85.4    85.3    85.3    84.4    84.4
   83.96   83.73   83.22   82.41   82.34   81.38   81.34   80.98   80.73    79.6
   78.96   78.85   78.87   78.89    82.7   85.62   86.82   86.82   86.83   86.83
   86.84   86.85   86.85   86.85   86.86   86.86   86.86   86.87   82.94   80.63
   79.28   79.26   79.25   78.75    78.9   78.35   78.14   77.77   77.43   77.47
   77.52   77.46   77.32   77.29   77.41   77.54    77.7    77.8    77.8    78.9
    78.9    79.2    79.2    78.6    78.6    78.6    78.6    81.4    81.4    82.4
    82.4    82.3    82.3    81.8    81.8    82.3   82.31   80.21    80.2      80
      80    80.4    80.4    81.2    81.2      81      81      82      82      82
      82    81.6    81.6    82.3    82.3    81.5    81.5    81.5    81.5    81.9
    81.9    81.7    81.7    81.2    81.2    80.3    80.3    82.8    82.8    83.2
    83.2    84.9    84.9    84.5    84.5    85.1    85.1   87.52    88.3    88.3
    88.6    88.6    88.3    88.3   88.71      89      89   89.25    89.8    89.8
    94.3    94.3
                                                                                
                                                                                
                                                                                
                                                                                
                    78.3   78.24   81.03   83.95   85.15   85.15   85.16   85.16
   85.17   85.18   85.18   85.18   85.19   85.19   85.19    85.2   81.27   78.96
   78.82   78.82
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                
  4253.7  4253.8  4283.7  4283.8  4413.7  4413.8  4423.7  4423.8  4453.7  4453.8
  4473.7  4473.8  4483.7  4483.8  4503.7  4503.8  4533.7  4533.8  4563.7  4563.8
  4573.7  4573.8  4613.7  4613.8  4643.7  4643.8  4653.7  4653.8  4673.7  4673.8
 4695.79  4713.8 4754.39 4801.09 4861.39 4902.49  4903.7  4913.7 4920.69  4923.7
 4925.39 4926.39  4926.5 4926.59 4947.29 4963.19 4969.69 4978.59 4981.39 4993.99
 5006.39 5017.09 5021.39 5023.99 5040.29 5044.69 5052.29 5062.69 5085.29 5098.59
 5106.38 5106.49 5106.59  5113.7  5123.7 5152.59  5163.7  5183.8 5205.49  5243.8
 5259.89  5273.7  5303.8 5311.39  5323.8  5338.2 5355.49  5438.2  5438.3  5468.2
  5468.3  5668.2  5668.3  5748.2  5748.3  6088.2  6088.3  6218.2  6218.3  6248.2
  6248.3  6278.2  6278.3  6288.2  6288.3  6318.2  6318.3  6358.2  6358.3  6428.2
  6428.3  6438.2  6438.3  6528.2  6528.3  6548.2  6548.3  6608.2  6608.3  6668.2
  6668.3  6728.2  6728.3  6758.2  6758.3  6848.2  6848.3  6938.2  6938.3  6958.2
  6958.3  7008.2  7008.3  7258.2  7258.3  7378.2  7378.3  7548.2  7548.3  7638.2
  7638.3  7798.2  7798.3  7898.2  7898.3  8048.2  8048.3  8562.3  8728.2  8728.3
  8748.2  8748.3  8778.2  8778.3  8795.8  8808.2  8808.3  8861.8  8978.2  8978.3
  9426.8  9426.9
    96.8    96.8    95.9    95.9    96.1    96.1    95.8   95.81   93.51    93.5
   91.31    91.3      91      91   88.41    88.4   86.01      86    84.8    84.8
    85.1    85.1    84.4    84.4    85.4    85.4    85.3    85.3    84.4    84.4
   83.96   83.73   83.22   82.41   82.34   81.38   81.34   80.98   80.73    79.6
   78.96   78.85   78.87   78.89    82.7   85.62   86.82   86.82   86.83   86.83
   86.84   86.85   86.85   86.85   86.86   86.86   86.86   86.87   82.94   80.63
   79.28   79.26   79.25   78.75    78.9   78.35   78.14   77.77   77.43   77.47
   77.52   77.46   77.32   77.29   77.41   77.54    77.7    77.8    77.8    78.9
    78.9    79.2    79.2    78.6    78.6    78.6    78.6    81.4    81.4    82.4
    82.4    82.3    82.3    81.8    81.8    82.3   82.31   80.21    80.2      80
      80    80.4    80.4    81.2    81.2      81      81      82      82      82
      82    81.6    81.6    82.3    82.3    81.5    81.5    81.5    81.5    81.9
    81.9    81.7    81.7    81.2    81.2    80.3    80.3    82.8    82.8    83.2
    83.2    84.9    84.9    84.5    84.5    85.1    85.1   87.52    88.3    88.3
    88.6    88.6    88.3    88.3   88.71      89      89   89.25    89.8    89.8
    94.3    94.3
                                                                                
                                                                                
                                                                                
                                                                                
                    78.3   78.24   81.03   83.95   85.15   85.15   85.16   85.16
   85.17   85.18   85.18   85.18   85.19   85.19   85.19    85.2   81.27   78.96
   78.82   78.82
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                
Pier Skew, UpSta & Num, DnSta & Num=  ,4939.7, 2 ,4939.7, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   69.13    81.1
     1.4     1.4
   69.13    81.1
Pier Skew, UpSta & Num, DnSta & Num=  ,4977.4, 2 ,4977.4, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   51.47   86.15
     1.4     1.4
   51.47   86.15
Pier Skew, UpSta & Num, DnSta & Num=  ,5016.9, 2 ,5016.9, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   49.65   86.18
     1.4     1.4
   49.65   86.18
Pier Skew, UpSta & Num, DnSta & Num=  ,5057.2, 2 ,5057.2, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   63.89    86.2
     1.4     1.4
   63.89    86.2
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=96.99

Type RM Length L Ch R = 1 ,32056   ,100.6,102,101
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
      3112880.78     13944296.74      3113127.43     13943239.91
      3113742.85      13939197.1
#Sta/Elev= 30
  4253.7   96.79  4423.8   95.79  4533.7   85.99  4563.7   84.79  4653.8   85.29
 4920.69   80.71 4925.39   78.94 4947.29   66.06 4978.59   52.25 4993.99   50.23
 5023.99   51.56 5040.29   56.73 5044.69      62 5052.29    64.2 5085.29   69.55
 5098.59   78.89 5311.39   77.27  5438.3   77.79  5468.2   78.89  6088.3   78.59
  6248.2   82.39  6318.3   82.29  6358.2   80.19  6428.2   79.99  6758.2   82.29
  7378.3   80.29  7798.2   84.89  8562.3   87.51  8978.3   89.79  9426.9   94.29
#Mann= 4 ,-1 , 0
  4253.7      .1       0 4920.69    .055       0 5098.59     .14       0
  8562.3    .055       0
#XS Ineff= 2 , 0
       0 4820.31    86.4 5324.22       0    82.9
Permanent Ineff=
       F       F
Bank Sta=4920.69,5098.59
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,31954.  ,660,787,485
BEGIN DESCRIPTION:
K100-00-00-S3_PIPELINE -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 3
      3112982.62      13944296.7      3113229.27     13943239.91
      3113844.68      13939197.1
#Sta/Elev= 30
  4252.9   96.46  4382.9    96.4  4412.9   93.43  4462.9   91.99  4502.9   86.93
  4592.9   83.61  4872.9   81.66  4932.9   73.71 4978.98    52.2 4994.43   50.15
 5023.82   51.76 5039.79    56.8  5044.1   61.69 5083.88   69.62  5092.9   76.16
  5122.9    81.8  5192.9   76.88  5332.9   75.41  5598.1   79.79  5788.1   78.28
  6018.1   81.97  6068.1   79.97  6158.1   80.91  6288.1   78.46  6348.1    78.5
  6445.1    84.3  6621.7    83.2  8218.1    85.3  8898.1   88.63  9427.5   94.03
#Mann= 5 ,-1 , 0
  4252.9      .1       0  4872.9    .055       0  5122.9     .12       0
  6288.1     .14       0  8218.1     .06       0
Bank Sta=4872.9,5122.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,31170.63,279,281,281
XS GIS Cut Line= 2
  3113731.512651 13944191.299335  3114051.009914 13939209.502111
#Sta/Elev= 30
       0      92  343.44      86  603.19   77.16  866.86   74.97  901.13      74
  915.71      72  942.15      64  970.72      52   984.5   49.55 1016.22      54
 1049.44      68 1073.72      74 1140.46      76 1334.99      76 1369.65      78
 1526.56      80  1553.2    81.9  2900.5    83.4  2925.2    81.5  2952.8    81.4
  2967.8    83.2  2978.4    81.3  3019.4    82.9  3037.7    81.2  3183.3    81.3
  3236.2    82.9    3286    81.9 4365.02      88 4753.16   91.78 4992.03   94.15
#Mann= 4 ,-1 , 0
       0     .14       0  866.86    .055       0 1140.46     .14       0
 4753.16     .06       0
#XS Ineff= 2 , 0
       0                    1325       0    82.9
Permanent Ineff=
       F       F
Bank Sta=866.86,1140.46
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,30887   ,850,782,366
BEGIN DESCRIPTION:
Cross Section K100-00-00-X14
Located At: 1200 FT D/S ALDINE WESTFIELD RD
END DESCRIPTION:
XS GIS Cut Line= 2
      3113960.92     13944229.22      3114474.81     13939208.39
#Sta/Elev= 30
  3951.1    93.9  4251.1    89.9  4371.1    82.8  4501.1    82.2  4531.1    78.2
  4581.1    63.7  4651.1    64.4  4691.1    75.3  4711.1    78.2  4761.1    74.8
  4923.4   74.62  4983.1   51.67    4999   49.33  5016.9   52.14  5055.3   63.58
  5079.3   75.36  5150.8   76.98  5508.2   75.81  5608.6   67.15  5718.9   67.15
  5782.7    83.5  6872.2    82.1  6891.1    76.6  6931.1    72.8  6961.1    77.1
  6976.5    82.1  7252.5    84.9  7519.5    84.4  8511.1      87  8998.2    94.2
#Mann= 6 ,-1 , 0
  3951.1     .14       0  4923.4    .055       0  5079.3     .14       0
  5508.2    .055       0  5718.9     .14       0  7519.5     .99       0
#XS Ineff= 2 ,-1
  5782.7    7525    83.5  5508.2  5782.7   75.81
Permanent Ineff=
       T       T
#Block Obstruct= 3 ,-1
    4500    4720   78.45    5508    5800    69.5  6561.1  7021.1    80.5
Bank Sta=4923.4,5079.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,30107.05,501,495,417
XS GIS Cut Line= 3
    3115435.5007 13944723.795656  3114512.507137 13942404.479152
  3114654.506214 13939245.001219
#Sta/Elev= 30
       0   98.11  947.05      76 1213.18   74.98 1492.93      78 1718.07    77.8
 1752.57      76 1771.67   71.99 1812.84      54    1831   48.42 1872.92      56
  1895.7      66 1927.08      76 2139.74   75.66  2391.2      80  2435.1   66.97
  2535.5   64.97    2637   66.95  2687.9    83.5 3449.22    81.4 3493.04      76
 3507.46      72 3534.14      72 3559.87   79.98 3566.02      82 3755.42    83.8
 4072.02    81.1 4111.32    84.1 4414.96      86 5188.27   86.07 5658.89   92.09
#Mann= 4 ,-1 , 0
       0     .14       0 1752.57    .055       0 1927.08     .14       0
 3559.87     .99       0
#XS Ineff= 2 ,-1
  2687.9  5658.9      95  2391.2  2687.9      80
Permanent Ineff=
       T       T
#Block Obstruct= 2 ,-1
  3354.6 3559.87      80    2391    2700    69.5
Bank Sta=1752.57,1927.08
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,29612.31,383,386,389
XS GIS Cut Line= 3
  3115956.163103 13944522.630517  3114938.503487 13942215.147049
  3114772.838338 13939233.168183
#Sta/Elev= 30
       0   97.55  428.39      92 1244.02      74 1282.76      70 1390.59      70
    1467      73 1509.35      66 1587.75    72.2 1643.86      64 1696.07      64
 1769.12      74 1814.41   73.91 1865.24   66.17 1895.28      54  1919.5   47.84
 2042.12      76 2339.57   74.08  2375.1   66.08  2478.9   63.98  2577.6   65.93
  2640.9    83.5 2705.97    82.3  3041.7    81.3 3094.58      72 3134.42      70
 3189.41   75.13  3213.8    80.4 4249.75      86 4960.45      86  5508.5   92.19
#Mann= 5 ,-1 , 0
       0     .14       0 1814.41    .055       0 2042.12     .14       0
 2339.57    .055       0 2705.97     .14       0
#XS Ineff= 2 ,-1
  2640.9  5508.5      95 2339.57  2640.9   74.08
Permanent Ineff=
       T       T
#Block Obstruct= 2 ,-1
 2926.64 3208.38      78 2333.17    2615    69.5
Bank Sta=1814.41,2042.12
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,29226   ,540,615,652
BEGIN DESCRIPTION:
Cross Section XS13.5
END DESCRIPTION:
XS GIS Cut Line= 5
      3116338.81      13944493.7      3115581.89     13942721.06
      3115492.28     13942523.91      3115323.43     13942112.79
      3115013.23       13939200.
#Sta/Elev= 30
  2914.4    97.3  3004.4    94.6  3464.4    90.6  4414.4    75.9  4764.4    76.3
  4804.4    74.6  4861.9    64.4  4911.9    67.4  4961.9    60.8  4977.1   51.28
  5016.6   47.39  5041.7   62.63  5073.4   71.76  5098.5    73.7  5188.5    68.7
  5338.5    73.3  5388.5    70.4  5468.5    76.7  5542.9    79.7  5642.9    75.5
  5702.9    68.6  5782.9    76.6  5842.9    76.3  5907.6    80.6  6249.9    80.8
  7052.9    86.7  8002.9    86.2  8152.9    89.1  8182.9    87.8  8432.2    93.6
#Mann= 3 ,-1 , 0
  2914.4     .14       0  4764.4    .055       0  5098.5     .14       0
#XS Ineff= 2 , 0
       0                    5856       0    82.9
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
  5542.9  5932.9    79.7
Bank Sta=4764.4,5098.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,28610.95,515,502,471
XS GIS Cut Line= 2
  3116500.492459 13943871.802072  3115234.334679 13939316.001199
#Sta/Elev= 30
       0   88.38  185.25      84  379.95      84  406.65      82  520.69      80
  778.03      78 1015.93      74 1184.78      74 1227.94      70 1287.47      70
  1300.9    72.2 1345.66   72.42  1368.2   71.26  1477.5   46.66    1508   53.07
 1521.94      60 1539.74      66 1548.44      68 1561.37   68.47 1682.88   70.45
 1728.99   68.79 1793.89   74.13 2432.35      76 2748.93      82 3191.66      82
  3335.9      84 3813.17      86 4323.13      86 4428.99      88 4728.47   90.24
#Mann= 3 , 0 , 0
       0    .014       0 1345.66    .055       0 1561.37    .014       0
#XS Ineff= 2 , 0
       0                 2857.95       0      95
Permanent Ineff=
       F       F
Bank Sta=1345.66,1561.37
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,28109   ,1672.9,1474,1115.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X13
Located At: 1700 FT U/S TREASCHWIG
END DESCRIPTION:
XS GIS Cut Line= 2
      3117058.14     13943770.89      3115585.92     13939236.17
#Sta/Elev= 30
  3499.8    95.6  3649.8    89.9  3789.8    89.3  3999.8      83  4149.8    84.8
  4179.8    80.9  4239.8    77.5  4479.8    77.2  4509.8    76.3  4529.8    73.3
  4549.8    71.4  4774.8   71.65    4834   75.81  4931.6   75.18  4952.7   65.53
  4977.1   49.96  5016.6   46.07  5041.7   61.31  5073.4   70.44  5115.7   72.67
  5169.8    70.2  5349.8    76.1  5549.8    77.9  5899.8    75.3  6689.8    83.4
  7049.8    84.7  7429.8      83  7479.8    85.1  7809.8    84.7  8267.5      90
#Mann= 5 ,-1 , 0
  3499.8     .14       0  4529.8    .026       0  4774.8     .14       0
  4931.6    .055       0  5115.7     .14       0
#Block Obstruct= 2 ,-1
    4500  4882.1   76.47    9000    9100      10
Bank Sta=4931.6,5115.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,26635   ,217.3,230,241
BEGIN DESCRIPTION:
Cross Section Xs12.7
END DESCRIPTION:
XS GIS Cut Line= 5
      3118447.31      13942388.1      3118302.29     13941884.14
       3117724.5     13941546.52      3117611.33     13941487.31
      3116024.94      13940530.6
#Sta/Elev= 30
  3755.7    90.1  3855.7    87.4  4065.7    75.7  4145.7    73.9  4185.7    70.1
  4255.7    70.5  4275.7    73.6  4320.2    76.5  4670.2    75.2  4770.2    76.5
  4900.2    71.5  4930.2    71.9  4949.4    65.8  4959.4    60.2  4960.9   57.79
  4972.9   50.18  4998.5   48.66 5024.02   49.82  5029.4    53.5  5049.4    56.4
  5077.1    64.8  5117.1    71.1  5147.1    73.4  5277.1    73.6  5397.1      77
  6237.1    81.9  6327.1    81.2  6447.1    83.6  6567.1    82.3  6929.6      84
#Mann= 3 , 0 , 0
  3755.7     .14       0  4930.2    .055       0  5147.1     .14       0
Bank Sta=4930.2,5147.1
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,26405   ,66.2,61,61
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
      3118564.24     13942279.19      3118445.85      13941767.5
      3116126.74     13940234.05
#Sta/Elev= 30
  3627.9   88.48  3987.9   72.28  4047.9   68.08  4077.9   71.98  4107.9   72.28
  4137.9   70.78  4802.7   76.25  4924.3    74.3  4960.9   58.21  4972.9    50.6
  4998.5   49.08  5036.4   51.65  5068.8   68.06  5127.2   67.67  5179.1   75.48
  5503.1   78.58  5583.1   77.18  5653.1   79.08  5673.1   77.68  5743.1   79.88
  5803.1   79.68  5843.1   82.48  5893.1   79.38  6003.1   79.38  6413.1   80.98
  6513.1   83.38  6633.1   81.98  6703.1   83.98  6813.1   82.08  6933.3   84.08
#Mann= 4 ,-1 , 0
  3627.9     .14       0  4924.3    .055       0  5179.1     .14       0
  5843.1     .99       0
#XS Ineff= 2 , 0
       0 4785.16   75.62 5226.07       0   76.63
Permanent Ineff=
       F       F
Bank Sta=4924.3,5179.1
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,26376   ,,,
BEGIN DESCRIPTION:
TREASCHWIG STREET
Structure ID: K100-00-00-S2
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,38,2.6,0, 148, 148, , , .95, 0, ,,,
  3627.9  3727.9  3737.9  3757.9  3827.9  3867.9  3987.9  4007.9  4017.9  4027.9
  4037.9  4047.9  4057.9  4067.9  4077.9  4107.9  4137.9  4147.9  4153.1  4163.1
  4173.1  4273.1  4283.1  4293.1  4353.1  4383.1  4403.1  4413.1  4423.1  4433.1
  4503.1  4513.1  4563.2  4579.7  4605.7    4654  4658.8  4701.7  4718.3  4751.2
  4774.8  4775.6 4788.49  4788.6 4788.71  4793.9 4794.01 4794.13  4794.2  4802.7
  4836.9  4854.7  4857.4  4871.6  4892.2  4914.9  4924.3  4960.9  4972.9  4974.4
  4975.3  4976.1  4976.3  4977.5  4998.5  5012.7    5021  5023.9 5024.02    5035
  5035.2  5036.4  5068.8    5095  5095.3  5096.8  5127.2  5153.8  5155.1  5155.3
  5179.1 5215.07 5215.19  5215.3  5215.4 5220.99  5221.1 5221.21  5221.4  5226.9
  5235.6    5271    5274  5330.3  5336.7    5390  5392.8  5399.7  5409.7  5448.9
  5449.6  5463.1  5503.1  5553.1  5573.1  5583.1  5593.1  5623.1  5653.1  5673.1
  5713.1  5743.1  5753.1  5773.1  5793.1  5803.1  5833.1  5843.1  5853.1  5863.1
  5873.1  5893.1  5913.1  5933.1  5953.1  6003.1  6153.1  6163.1  6183.1  6213.1
  6243.1  6253.1  6273.1  6413.1  6453.1  6513.1  6533.1  6543.1  6633.1  6703.1
  6733.1  6793.1  6813.1  6853.1  6873.1  6913.1  6923.1  6933.3
    88.5    83.3      83    81.7    79.7    77.1    72.3      71    70.8    70.1
    68.8    68.1    68.6    70.6      72    72.3    70.8    71.2    71.6    71.2
    71.9    72.6      73    72.7    73.1    73.9    73.7      73    73.8    73.5
    74.1    73.9   74.93    76.9   77.46   78.51   78.61   79.55   79.98   80.82
   81.45   81.47   81.86   85.36   85.36   85.52   85.52   85.53   85.53   85.73
   86.55   86.98   87.03   87.29   87.67   88.09   88.18   88.55   88.67   88.69
    88.7    88.7    88.7   88.71   88.83   88.92   88.97   88.98   88.98   89.05
   89.05   89.05   88.96   88.89   88.89   88.88   88.62    88.4   88.39   88.39
   87.98   87.36   87.36   87.36   87.36   87.21   87.21   83.71    83.7   83.59
   83.41   82.85    82.8   81.94   81.86   81.17   80.95    80.4    80.7   79.62
    79.6    77.6    78.6    77.5    77.6    77.2    77.3      79    79.1    77.7
    78.4    79.9    79.4    79.9    79.5    79.7    82.2    82.5    81.9    80.5
    79.9    79.4    79.8    79.6    79.6    79.4    80.3    80.1    80.5    80.7
    79.9      80      81      81    82.4    83.4      83    82.4      82      84
      83      83    82.1    83.1      83    83.6    84.1    84.1
                                                                                
                                                                                
                                                                                
                                                                                
                                                                   79.03   79.23
   80.05   80.48   80.53   80.79   81.17   81.59   81.68   82.05   82.17   82.19
    82.2    82.2    82.2   82.21   82.33   82.42   82.47   82.48   82.48   82.55
   82.55   82.55   82.46   82.39   82.39   82.38   82.12    81.9   81.89   81.89
   81.48   80.86   80.86   75.36
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                
  3627.9  3727.9  3737.9  3757.9  3827.9  3867.9  3987.9  4007.9  4017.9  4027.9
  4037.9  4047.9  4057.9  4067.9  4077.9  4107.9  4137.9  4147.9  4153.1  4163.1
  4173.1  4273.1  4283.1  4293.1  4353.1  4383.1  4403.1  4413.1  4423.1  4433.1
  4503.1  4513.1  4563.2  4579.7  4605.7    4654  4658.8  4701.7  4718.3  4751.2
  4774.8  4775.6 4788.49  4788.6 4788.71  4793.9 4794.01 4794.13  4794.2  4802.7
  4836.9  4854.7  4857.4  4871.6  4892.2  4914.9  4924.3  4960.9  4972.9  4974.4
  4975.3  4976.1  4976.3  4977.5  4998.5  5012.7    5021  5023.9 5024.02    5035
  5035.2  5036.4  5068.8    5095  5095.3  5096.8  5127.2  5153.8  5155.1  5155.3
  5179.1 5215.07 5215.19  5215.3  5215.4 5220.99  5221.1 5221.21  5221.4  5226.9
  5235.6    5271    5274  5330.3  5336.7    5390  5392.8  5399.7  5409.7  5448.9
  5449.6  5463.1  5503.1  5553.1  5573.1  5583.1  5593.1  5623.1  5653.1  5673.1
  5713.1  5743.1  5753.1  5773.1  5793.1  5803.1  5833.1  5843.1  5853.1  5863.1
  5873.1  5893.1  5913.1  5933.1  5953.1  6003.1  6153.1  6163.1  6183.1  6213.1
  6243.1  6253.1  6273.1  6413.1  6453.1  6513.1  6533.1  6543.1  6633.1  6703.1
  6733.1  6793.1  6813.1  6853.1  6873.1  6913.1  6923.1  6933.3
    88.5    83.3      83    81.7    79.7    77.1    72.3      71    70.8    70.1
    68.8    68.1    68.6    70.6      72    72.3    70.8    71.2    71.6    71.2
    71.9    72.6      73    72.7    73.1    73.9    73.7      73    73.8    73.5
    74.1    73.9   74.93    76.9   77.46   78.51   78.61   79.55   79.98   80.82
   81.45   81.47   81.86   85.36   85.36   85.52   85.52   85.53   85.53   85.73
   86.55   86.98   87.03   87.29   87.67   88.09   88.18   88.55   88.67   88.69
    88.7    88.7    88.7   88.71   88.83   88.92   88.97   88.98   88.98   89.05
   89.05   89.05   88.96   88.89   88.89   88.88   88.62    88.4   88.39   88.39
   87.98   87.36   87.36   87.36   87.36   87.21   87.21   83.71    83.7   83.59
   83.41   82.85    82.8   81.94   81.86   81.17   80.95    80.4    80.7   79.62
    79.6    77.6    78.6    77.5    77.6    77.2    77.3      79    79.1    77.7
    78.4    79.9    79.4    79.9    79.5    79.7    82.2    82.5    81.9    80.5
    79.9    79.4    79.8    79.6    79.6    79.4    80.3    80.1    80.5    80.7
    79.9      80      81      81    82.4    83.4      83    82.4      82      84
      83      83    82.1    83.1      83    83.6    84.1    84.1
                                                                                
                                                                                
                                                                                
                                                                                
                                                                   79.03   79.23
   80.05   80.48   80.53   80.79   81.17   81.59   81.68   82.05   82.17   82.19
    82.2    82.2    82.2   82.21   82.33   82.42   82.47   82.48   82.48   82.55
   82.55   82.55   82.46   82.39   82.39   82.38   82.12    81.9   81.89   81.89
   81.48   80.86   80.86   75.36
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4855.2, 2 ,4855.2, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   74.06    81.5
     1.5     1.5
   73.74   81.18
Pier Skew, UpSta & Num, DnSta & Num=  ,4915, 2 ,4915, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   73.51    82.6
     1.5     1.5
   73.19   82.28
Pier Skew, UpSta & Num, DnSta & Num=  ,4975.3, 2 ,4975.3, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   49.06    83.2
     1.5     1.5
   48.74   82.88
Pier Skew, UpSta & Num, DnSta & Num=  ,5035, 2 ,5035, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   50.57   83.55
     1.5     1.5
   50.25   83.23
Pier Skew, UpSta & Num, DnSta & Num=  ,5095, 2 ,5095, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   66.03   83.39
     1.5     1.5
   65.71   83.07
Pier Skew, UpSta & Num, DnSta & Num=  ,5155.1, 2 ,5155.1, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   70.02    82.9
     1.5     1.5
    69.7   82.58
BR Coef= 1 , 1 , 1 ,.9, 0 ,,,.8,0,1.2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=88.48

Type RM Length L Ch R = 1 ,26344   ,212.7,192,198.1
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
      3118601.85     13942239.14      3118481.66     13941719.68
       3116155.9     13940181.83
#Sta/Elev= 30
  3627.9   88.17  3987.9   71.97  4047.9   67.77  4077.9   71.67  4107.9   71.97
  4137.9   70.47  4802.7   75.94  4924.3   73.99  4960.9    57.9  4972.9   50.29
  4998.5   48.77  5036.4   51.34  5068.8   67.75  5127.2   67.36  5179.1   75.17
  5503.1   78.27  5583.1   76.87  5653.1   78.77  5673.1   77.37  5743.1   79.57
  5803.1   79.37  5843.1   82.17  5893.1   79.07  6003.1   79.07  6413.1   80.67
  6513.1   83.07  6633.1   81.67  6703.1   83.67  6813.1   81.77  6933.3   83.77
#Mann= 4 ,-1 , 0
  3627.9     .14       0  4924.3    .055       0  5179.1     .14       0
  5843.1     .99       0
#XS Ineff= 2 , 0
       0 4785.16   75.28 5222.66       0   76.52
Permanent Ineff=
       F       F
Bank Sta=4924.3,5179.1
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,26152.  ,177.1,196,200.8
BEGIN DESCRIPTION:
K100-00-00-S2_TREASCHWIG -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 3
      3118702.67      13942340.4      3118493.99     13941498.07
      3116223.96     13939999.14
#Sta/Elev= 30
  3372.1   90.65  3522.1   85.73  3602.1   81.02  3722.1   77.62  3852.1   70.62
  3902.1   73.16  3962.1   71.17  4042.1   72.63  4142.1    77.1  4192.1   75.27
  4299.9   73.96  4479.9   76.52  4569.9   73.62  4769.9   74.49  4819.9   75.87
  4889.9   83.78  4909.9   82.15  4919.9   79.09 4955.42   59.94 4978.77   49.44
  4998.5    48.5 5028.82   50.28 5054.74   60.36  5139.9   75.03  5179.9   73.21
  5319.9    73.9  5659.9   80.09  6269.9   81.15  6509.9   83.83  6960.2   83.97
#Mann= 3 ,-1 , 0
  3372.1     .14       0  4889.9    .055       0  5139.9     .14       0
Bank Sta=4889.9,5139.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,25956   ,240.5,1533,1663.5
BEGIN DESCRIPTION:
Cross Section XS12.5
END DESCRIPTION:
XS GIS Cut Line= 4
      3118745.12      13942263.8      3118571.43     13941308.83
      3117914.54     13940881.87      3116246.86     13939844.01
#Sta/Elev= 30
    3322    88.3    3512    81.4    3652    73.2    3702    73.1    3792    67.5
    3882    72.6    4192    76.9  4292.6    73.9  4422.6    72.4  4682.6      75
  4772.6    71.1  4832.6    71.4  4862.6    73.8  4892.6    72.3  4942.6    66.6
  4952.6    64.4  4960.9   57.36  4972.9   49.75  4998.5   48.23  5036.4    50.8
  5072.6    69.2  5096.1    75.1  5106.1    75.8  5196.1    72.9  5426.1    72.5
  5716.1    78.7  6036.1    80.4  6076.1    81.7  6516.1    83.1  7040.3    83.4
#Mann= 4 ,-1 , 0
    3322     .14       0  4862.6    .055       0  5106.1     .14       0
  6036.1     .99       0
Bank Sta=4862.6,5106.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,24423   ,553.2,529,408.2
BEGIN DESCRIPTION:
Cross Section XS12.3
END DESCRIPTION:
XS GIS Cut Line= 6
      3118755.99     13942277.68      3118755.99     13941458.79
      3118995.02     13941039.98      3119147.41     13940825.31
      3119249.26     13938826.97      3119152.56     13938090.55
#Sta/Elev= 30
  3649.2   89.27  3699.2   86.12  3849.2   82.43  3959.2   74.42  4089.2   71.95
  4149.2   66.57  4219.2    71.8  4488.1   76.32  4588.1   74.26  4628.1   62.66
  4708.1   64.86  4748.1   62.31  4848.1   62.32 4913.46   69.48 4949.79   61.86
 4978.13    47.4 4998.35    46.1  5021.9   47.64 5059.84   60.12 5061.51   63.54
 5075.78   68.35 5110.78   75.06  5853.6   77.76  6563.6   83.05  6593.6   81.25
  6683.6   82.91  7214.5   82.86  7324.5   85.06  7394.5    83.1  7957.2   86.36
#Mann= 3 ,-1 , 0
  3649.2      .1       0 4913.46    .055       0 5110.78     .14       0
Bank Sta=4913.46,5110.78
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,23894   ,576,605,686.1
BEGIN DESCRIPTION:
Cross Section XS12.2
END DESCRIPTION:
XS GIS Cut Line= 5
      3118765.06      13942270.9      3119328.39      13941421.7
      3119399.27     13941335.63      3119550.56     13941101.68
      3119269.07      13938005.8
#Sta/Elev= 30
  3931.8      89  4011.8      85  4061.8    85.2  4221.8    76.4  4511.8    69.2
  4581.8    64.3  4691.8    64.9  4701.8    66.7  4741.8    80.9  4771.8      85
  4801.8    84.7  4851.8    74.4  4911.8    69.4  4949.7   60.69  4977.7   46.95
  4998.3   45.36  5022.2    47.1  5060.7   59.68  5062.4      64  5092.4    72.1
  5112.4    74.8  5292.4    76.6    5751    74.8    6131    78.8    6321    77.8
    6821    83.2    7831    83.4    8041    86.6    8171    84.9  8449.6    86.1
#Mann= 3 , 0 , 0
  3931.8     .14       0  4851.8    .055       0  5112.4     .14       0
Bank Sta=4851.8,5112.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,23289   ,943.4,721,294.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X12
END DESCRIPTION:
XS GIS Cut Line= 3
      3118996.51     13942510.03      3120235.05     13941408.02
      3120032.95       13938141.
#Sta/Elev= 30
  4020.2    88.3  4210.2    78.7  4410.2    74.6  4450.2    76.1  4500.2    83.9
  4610.2    86.1  4830.2    86.1  4844.8   82.87  4872.2   81.46    4931   71.24
  4977.7   46.11  4998.3   44.52  5022.2   46.26  5060.7   58.84  5079.2   70.87
    5122   68.15  5250.2    75.9  5670.2      76    5818    72.9    6128    75.5
    6168    73.9    6928    74.6    7098    72.8    7538    75.7    7608      81
    7668    82.2    7748    81.1    8108    84.2    8138    82.6  8951.3    83.6
#Mann= 3 ,-1 , 0
  4020.2      .1       0    4931    .055       0  5079.2     .14       0
Bank Sta=4931,5079.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,22568   ,1646.5,1888,1308.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X11
END DESCRIPTION:
XS GIS Cut Line= 3
       3120205.8     13942909.87      3120505.66     13941417.28
      3120433.99      13937828.5
#Sta/Elev= 30
  4269.5    86.2  4409.5    84.8  4749.5    70.6  4829.5    71.4  4890.8    69.7
  4934.1   70.75  4956.5   57.79  4983.1   45.96  5000.5   44.02  5016.8   46.39
  5041.3   58.26  5056.5   68.93    5121   71.62  5199.5    71.7  5309.5    75.9
  5449.5    77.4  5629.5    74.1  5799.6   75.86  6061.9    72.3  6251.9    75.2
  6441.9      76  6911.9    70.7  7331.9    73.8  7621.9    73.8  7931.9    79.6
  8371.9    82.7  8841.9    83.1  8961.9    81.3  9241.9    81.5  9381.4    84.1
#Mann= 4 ,-1 , 0
  4269.5      .1       0  4934.1    .055       0  5056.5     .14       0
  5799.6      .1       0
Bank Sta=4934.1,5056.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,20680   ,1700.9,1367,613.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X10
END DESCRIPTION:
XS GIS Cut Line= 4
      3121613.92     13943062.94      3121580.73     13941488.44
      3121926.44     13940975.97      3120589.62     13937733.08
#Sta/Elev= 30
  3060.6    87.9  3260.6    83.1  3480.6    73.1  3760.6   72.98  3870.6    71.2
  3960.6    66.8  4000.6      67  4050.6      72  4140.6      74  4490.6    71.1
  4715.4      66  4785.4    68.7  4855.4    64.4    4905   67.25  4973.4   46.24
  4990.6   44.59  5025.9   46.41  5058.5   59.23  5070.8   72.76  5453.6    68.5
  5583.6    71.4  5823.6    68.7  6343.6    74.5  6923.6    72.7  7193.6    74.2
  7563.6    76.7  7623.6    79.1  7963.6    82.4  8683.6    82.8  8761.2    81.2
#Mann= 4 ,-1 , 0
  3060.6      .1       0  3760.6     .14       0    4905    .055       0
  5070.8     .14       0
#Block Obstruct= 2 ,-1
    3780    4118      73    9000    9100      10
Bank Sta=4905,5070.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,19313   ,817.5,702,396.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X09
END DESCRIPTION:
XS GIS Cut Line= 4
      3123567.05     13941769.53      3122805.27     13940965.55
      3122481.33     13940473.87      3120659.06     13937646.27
#Sta/Elev= 30
  3604.4    91.1  3894.4    84.5  3934.4    80.6  3994.4    81.8  4093.5   79.57
  4324.4    70.7  4364.4    71.3  4509.1   67.36  4614.4    69.2  4674.4    65.8
    4722    69.1    4772    66.4  4865.1   65.67  4905.2   69.48  4944.1   51.66
  4971.3   45.89  5001.6   42.93  5028.7   45.67  5054.3   60.43  5072.7   67.08
    5100    65.9    5142    71.4    5182    71.2    5242      65  5360.8    64.6
  5960.8      73  6840.8    72.4  7820.8    81.2  8450.8    82.6  8664.7      81
#Mann= 5 ,-1 , 0
  3604.4      .1       0  4093.5     .06       0  4509.1     .12       0
  4905.2    .055       0  5072.7     .14       0
#Block Obstruct= 2 ,-1
    5170    5780   71.34    9000    9100      10
Bank Sta=4905.2,5072.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,18611   ,759.2,1428,1893
BEGIN DESCRIPTION:
Cross Section K100-00-00-X8
END DESCRIPTION:
XS GIS Cut Line= 4
      3123896.91     13941674.05      3123719.99     13940567.04
      3122953.02      13940388.6      3120745.87     13937550.78
#Sta/Elev= 30
  3344.2    91.4  3554.2    87.9  3704.2    81.7  3824.2    82.2  3889.9    78.4
  4144.2      74  4264.2    74.8  4374.2    71.3  4454.2    72.5  4655.3    66.5
  4705.3    61.9  4765.3      67  4860.6   70.18  4915.2   72.71  4978.1   45.95
  4998.9   44.98  5021.9    45.9  5054.7   65.87  5122.8   68.53  5155.3    61.4
  5205.3    69.7  5245.3    71.4  5622.7    69.1  5922.7    73.2  6822.7      73
  8232.7    82.3  8382.7    80.2  8592.7    82.4  8847.7    80.4  8847.8    80.4
#Mann= 7 ,-1 , 0
  3344.2     .08       0  3889.9     .06       0  4860.6     .14       0
  4915.2    .055       0  5054.7    .055       0  5122.8     .14       0
  8847.7     .99       0
#Block Obstruct= 2 ,-1
    4452  4911.3   72.42  5122.9    5212    68.6
Bank Sta=4915.2,5054.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,17183   ,515.7,696,745.7
BEGIN DESCRIPTION:
Cross Section XS07.5
END DESCRIPTION:
XS GIS Cut Line= 5
      3124210.17       13941622.      3124138.91     13939801.91
       3124054.9     13939510.15      3124023.61     13939402.85
      3123710.25     13934592.41
#Sta/Elev= 30
  2806.1    91.1  2866.1    87.8  3036.1      89  3296.1    79.8  3446.1    78.3
  3526.1    73.3  4296.1      69  4566.1    71.3  4687.6    66.1  4917.6    68.2
  4940.7   60.72  4954.4   60.19  4975.5    44.5  5015.4    42.6  5049.9   52.17
    5073      64    5103    67.9    5283    66.1    5703    74.2    6293    76.3
    6813    75.5    7103    71.6    7373    71.5    7493    75.4    7823    77.5
    7903    75.2    8923    81.5    9643      85    9793    83.1  9863.7    86.1
#Mann= 5 ,-1 , 0
  2806.1     .08       0  4917.6    .055       0    5103     .14       0
    7903      .1       0    8923     .14       0
#XS Ineff= 2 , 0
       0                    6148       0      80
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
    5123    5435    68.4    4615  4827.6      69
Bank Sta=4917.6,5103
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,16487   ,2082.7,1884,1930.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X07
END DESCRIPTION:
XS GIS Cut Line= 4
      3124423.82     13941555.12      3124694.55     13939961.16
      3124736.43     13939009.79      3124618.27      13934520.4
#Sta/Elev= 30
  2912.3    90.7  3632.3      71  3832.3    70.9  3922.3    68.5  4062.3    69.9
  4262.3    66.8  4502.3      69  4639.1    65.9  4717.2   67.94  4870.3   66.67
  4927.3   63.47  4940.7   59.56  4954.4   59.03  4975.5   43.34  5015.4   41.44
  5049.9   51.01  5071.8   66.66    5168   65.97  5169.1    60.1  5199.1    59.5
  5239.1    64.6  5791.4    73.4  6461.4    73.9  6821.4    76.4  6861.4    75.2
  8680.3    81.1  9201.4    81.8  9271.4    80.5  9631.4    84.3  9972.3    84.4
#Mann= 4 ,-1 , 0
  2912.3     .08       0  4717.2    .055       0  5071.8     .14       0
  8680.3      .1       0
#Block Obstruct= 2 ,-1
    5116    5350   66.66    9000    9100      10
Bank Sta=4717.2,5071.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,14603   ,1451.8,1840,1473.8
BEGIN DESCRIPTION:
Cross Section k100-00-00-X06
END DESCRIPTION:
XS GIS Cut Line= 4
      3126857.62     13942749.57      3126553.71     13939779.77
      3126564.45     13939234.05      3127837.61     13935394.18
#Sta/Elev= 30
  1737.9    90.2  2507.9    79.6  3313.9   75.81  3727.9    74.7  3787.9    69.1
    3937    68.8  4127.9    65.6  4469.1   68.14  4607.9    63.1  4915.1   68.49
  4946.7   62.57  4976.9   45.12  4998.8   42.62  5021.3    42.7  5064.3   68.48
  5143.2    61.4    5279    68.2    5439    60.5    5549    60.7    5939      72
  6556.1   78.19  8421.3   81.63    8489    81.2    8599    95.8    8709    85.1
    8809    81.2    9119      81    9199    84.2    9249    92.4  9314.5    95.5
#Mann= 8 , 1 , 0
  1737.9     .08       0  3313.9     .14       0    3937     .08       0
  4469.1     .14       0  4915.1    .055       0  5064.3     .14       0
  6556.1    .055       0  8421.3     .99       0
#Block Obstruct= 2 ,-1
    5067    5800    68.2    9000    9100      10
Bank Sta=4915.1,5064.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,12763   ,921.3,1346,1378.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X05
END DESCRIPTION:
XS GIS Cut Line= 4
      3127104.38     13942999.57      3127933.27     13940859.64
      3127895.78     13939748.74      3128916.88     13936159.29
#Sta/Elev= 30
  2234.7      92  3234.7    76.4  3474.7    78.8  3884.7    74.2  3954.7    77.4
  4110.3   72.68  4214.7    71.4  4354.7    64.2  4514.7    69.2  4609.5    63.7
    4650   64.76  4709.5    65.8  4769.5    61.8  4834.2   65.99    4914   65.24
  4921.5   56.99  4942.7   52.41  4955.2   44.78    5035   41.89  5060.7   52.97
    5083   54.46  5100.1   65.09  5189.5    64.5  5239.5    60.1  5671.1    68.7
  6271.1    75.3  7511.1    77.4  8311.1    81.3  8601.1      86  9372.9    87.5
#Mann= 5 ,-1 , 0
  2234.7     .14       0  4110.3     .08       0    4650     .14       0
    4914    .055       0  5100.1     .14       0
Bank Sta=4914,5100.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,11417   ,598.7,528,397
BEGIN DESCRIPTION:
Cross Section XS04.7
END DESCRIPTION:
XS GIS Cut Line= 5
      3127836.73     13943417.45      3128984.47     13940132.05
      3129041.98      13940069.3      3129260.02     13939743.14
      3129340.86     13936369.01
#Sta/Elev= 30
  1461.5   92.32  1681.5   90.62  1961.5   85.03  2011.5    81.6  2781.5   75.41
  2851.5   69.12  3331.5   68.51  3421.5   71.79  3881.5   65.77  4021.5   66.77
  4261.5    62.8  4331.5    64.7  4361.5   61.15  4651.5   64.67  4681.5    61.5
  4873.1    59.1 4909.24   43.64 4990.29   41.55 5080.54    60.5  5096.7   64.81
  5789.1   67.71  5949.1   61.49  6089.1   65.42  6149.1   61.28  6299.1   61.92
  6389.1   66.96  7089.1   76.78  7739.1   78.18  8219.1   84.15  8794.2   86.43
#Mann= 5 ,-1 , 0
  1461.5      .1       0  4021.5     .14       0  4873.1    .055       0
 5080.54     .14       0  5096.7     .14       0
#XS Ineff= 2 , 0
       0    4100      77    6000       0      77
Permanent Ineff=
       F       F
Bank Sta=4873.1,5096.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,10889.  ,352.7,260,165.6
BEGIN DESCRIPTION:
K100-00-00-S1_CYPRESSWOOD DR -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3128338.66      13943530.8      3129245.96     13940765.14
      3129477.23     13940125.55      3129463.66     13937327.68
#Sta/Elev= 30
  1815.3   85.86  1915.3   88.04  3225.3   74.83  3415.3    69.2  3485.3   75.09
  3545.3   68.18  3645.3   66.59  3745.3   70.69  3985.3   62.04  4205.3   67.22
  4245.3    63.9  4625.3   64.17    4766   50.44    4806    63.3    4866   64.25
 4885.82   61.02 4921.15   45.32 5000.38   41.43    5096   61.19    5206   66.39
  5636.1   61.75  5946.1   66.79  6056.1   64.22  6166.1   69.93  6226.1   60.63
  6276.1   58.51  6726.1   69.63  7376.1   80.17  7866.1   80.36    8204   79.42
#Mann= 6 ,-1 , 0
  1815.3      .1       0  3225.3     .14       0    4866    .055       0
    5096     .14       0  6726.1     .05       0  7866.1     .14       0
#XS Ineff= 2 , 0
         4555.56   78.58 5576.83           78.68
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
  4624.9 4858.16   63.56
Bank Sta=4866,5096
XS Rating Curve= 0
Exp/Cntr=.5,.3
