HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 3 ,174305  ,,,
BEGIN DESCRIPTION:
US 290
Structure ID: K100-00-00-S26
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,198,2.6,0, 60, 60, , , .95, 0, ,,,
 -1206.2  -865.5  -825.5  -785.5  -765.5  -745.5  -725.5  -636.2  -566.2  -496.2
  -486.2  -446.2  -406.2  -386.2  -376.2  -346.2  -256.2  -246.2  -216.2    68.1
   558.1   618.5   968.5   978.5   988.5   998.5  1018.5  1068.5  1088.5  1208.5
  1268.5  1278.5  1298.5  1348.5  1358.5  1378.5  1590.5  1620.5  1890.5  1910.5
  1960.5  1980.5  2290.5  2480.5  4410.5  4627.7  4839.7  4839.9  4940.3 5138.81
 5160.09  5160.2  5162.5  5550.9  7520.9  7810.9  8040.9  8081.8  8280.9  9109.8
   146.8  147.11  146.61  147.21  146.61  146.61  147.31     146   146.9     147
   147.6   147.5   148.3     148   148.4   147.6   149.2     149   149.9   154.7
   164.8   165.7   166.7   166.3   165.3   163.6   158.9   145.5   142.2  142.11
  142.14   143.3   147.9   162.2   164.7   166.2   165.1   164.4   159.9     159
   158.1   157.3   150.1   146.6   146.4  147.89  148.87  148.87  149.09   148.7
  148.33  148.33  148.29   146.7   143.6   143.6   144.2   143.9   144.5   144.8
                                                                                
                                                                                
                                                                                
                                                                                
                                                          145.37  145.59   145.2
  144.83  144.06
 -1206.2  -865.5  -825.5  -785.5  -765.5  -745.5  -725.5  -636.2  -566.2  -496.2
  -486.2  -446.2  -406.2  -386.2  -376.2  -346.2  -256.2  -246.2  -216.2    68.1
   558.1   618.5   968.5   978.5   988.5   998.5  1018.5  1068.5  1088.5  1208.5
  1268.5  1278.5  1298.5  1348.5  1358.5  1378.5  1590.5  1620.5  1890.5  1910.5
  1960.5  1980.5  2290.5  2480.5  4410.5  4627.7  4839.7  4839.9  4940.3 5138.81
 5160.09  5160.2  5162.5  5550.9  7520.9  7810.9  8040.9  8081.8  8280.9  9109.8
   146.8  147.11  146.61  147.21  146.61  146.61  147.31     146   146.9     147
   147.6   147.5   148.3     148   148.4   147.6   149.2     149   149.9   154.7
   164.8   165.7   166.7   166.3   165.3   163.6   158.9   145.5   142.2  142.11
  142.14   143.3   147.9   162.2   164.7   166.2   165.1   164.4   159.9     159
   158.1   157.3   150.1   146.6   146.4  147.89  148.87  148.87  149.09   148.7
  148.33  148.33  148.29   146.7   143.6   143.6   144.2   143.9   144.5   144.8
                                                                                
                                                                                
                                                                                
                                                                                
                                                          145.37  145.59   145.2
  144.83  144.06
Pier Skew, UpSta & Num, DnSta & Num=  ,4909, 2 ,4909, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  134.19  146.57
     1.5     1.5
  134.19  146.57
Pier Skew, UpSta & Num, DnSta & Num=  ,4989.1, 2 ,4989.1, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   123.4  146.56
     1.5     1.5
   123.4  146.56
Pier Skew, UpSta & Num, DnSta & Num=  ,5068.4, 2 ,5068.4, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  136.65  146.37
     1.5     1.5
  136.65  146.37
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,1,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=147.3

Type RM Length L Ch R = 1 ,174181  ,22.5,21,20.3
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3015548.49       13913846.      3020042.83     13910583.81
       3020688.7     13910104.62      3023528.42      13907901.8
#Sta/Elev= 30
  -819.7   147.2  -415.5   144.3  -285.5   147.2   -65.5   142.9    -5.5   144.7
   164.5   142.5   204.5   144.8   234.5   142.1   424.5   140.5   454.5     143
   584.5   143.9   754.5   141.9  3054.5   141.4  4564.5   145.8  4592.8  142.77
  4757.2  145.57  4808.9  143.26    4971  127.42  4999.4  120.23  5009.3  121.26
  5017.1  126.38  5071.2  135.86    5132  137.89  5178.9  143.69  5218.4   146.1
  5382.8  143.59  6641.8   141.6  7841.8   143.6  8691.8   140.1  9086.3   144.8
#Mann= 3 ,-1 , 0
  -819.7     .99       0  4808.9    .045       0  5178.9     .99       0
#XS Ineff= 2 , 0
       0 4788.93  143.93 5204.15       0  144.38
Permanent Ineff=
       F       F
Bank Sta=4808.9,5178.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,174160  ,37,23,21.1
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3016515.25     13913236.64      3020030.42     13910623.19
      3020595.91     13910195.26      3021864.42     13909293.54
#Sta/Elev= 30
   288.1  155.66   588.2  156.66   608.1  155.76   618.1  152.66   638.1  153.46
   658.2  147.26   668.1  147.76   688.2  142.46  1728.2  143.16  2018.1  140.26
  2288.2  141.66  2318.1  139.66  2718.2  141.66  3188.1  133.36  3668.2  132.66
  3738.1  134.56  3768.1  131.76  4118.1  130.56    4775  131.19 4937.23  133.64
 4975.13  130.01 4999.73  120.07 5048.23  132.99  5239.4  134.22  5997.5  143.46
  6027.6  140.36  6387.5  143.46  6837.6  143.26  6907.5  151.96    6934  152.26
#Mann= 7 ,-1 , 0
   288.1     .99       0  2718.2     .14       0    4775     .12       0
 4975.13    .045       0 5048.23      .2       0  5239.4     .14       0
  5997.5     .99       0
#XS Ineff= 2 , 0
       0 4759.52  143.53 5219.72       0  143.38
Permanent Ineff=
       F       F
Bank Sta=4975.13,5048.23
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,174149  ,,,
BEGIN DESCRIPTION:
PL1_K100-00-00-S25A
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,2,2.6,0, 60, 60, , , .95, 0, ,,,
   288.1   588.2   608.2   618.1   628.2   638.2   648.2   658.2   668.2   688.2
  1728.2  1868.1  1988.2  2018.1  2058.1  2258.2  2288.2  2318.1  2718.2  3018.2
  3068.2  3148.1  3398.1  3538.1  3668.2  3738.2  3748.2  3768.2  4038.2  4118.1
  4188.2  4548.1  4698.3  4718.4  4778.3  4788.4  4798.4  4858.3 4864.14 4864.23
 4911.83 5070.23 5112.32 5112.43 5112.53  5138.3  5377.6  5707.5  5837.6  5917.5
  5997.6  6027.6  6067.5  6387.5  6777.6  6837.6  6857.5  6887.5  6907.5    6934
   155.6   156.6   155.7  152.63  154.31   153.4   151.8   147.2   147.7  142.41
   143.1     141   141.5   140.2   141.1   140.6  141.61   139.6   141.6  137.41
   134.5   133.6   132.3   133.4   132.6   134.5   132.7   131.7  131.61   130.5
  132.01   130.8  131.01   131.9     131  132.71   131.6   132.6  135.22  135.23
  143.05  143.81  138.51   138.5  138.49   136.1     135   140.1   140.2   142.8
  143.41   140.3   142.1   143.4   144.2   143.2  144.41  149.91  151.91   152.2
                                                                                
                                                                                
                                                                                
                                                                          133.73
  141.55  142.31  137.01  134.02
                                                                                
   288.1   588.2   608.2   618.1   628.2   638.2   648.2   658.2   668.2   688.2
  1728.2  1868.1  1988.2  2018.1  2058.1  2258.2  2288.2  2318.1  2718.2  3018.2
  3068.2  3148.1  3398.1  3538.1  3668.2  3738.2  3748.2  3768.2  4038.2  4118.1
  4188.2  4548.1  4698.3  4718.4  4778.3  4788.4  4798.4  4858.3 4864.14 4864.23
 4911.83 5070.23 5112.32 5112.43 5112.53  5138.3  5377.6  5707.5  5837.6  5917.5
  5997.6  6027.6  6067.5  6387.5  6777.6  6837.6  6857.5  6887.5  6907.5    6934
   155.6   156.6   155.7  152.63  154.31   153.4   151.8   147.2   147.7  142.41
   143.1     141   141.5   140.2   141.1   140.6  141.61   139.6   141.6  137.41
   134.5   133.6   132.3   133.4   132.6   134.5   132.7   131.7  131.61   130.5
  132.01   130.8  131.01   131.9     131  132.71   131.6   132.6  135.22  135.23
  143.05  143.81  138.51   138.5  138.49   136.1     135   140.1   140.2   142.8
  143.41   140.3   142.1   143.4   144.2   143.2  144.41  149.91  151.91   152.2
                                                                                
                                                                                
                                                                                
                                                                          133.73
  141.55  142.31  137.01  134.02
                                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4888.2, 2 ,4888.2, 2 , 0 , 0 , 0 ,,
     1.4     1.4
  132.21  138.79
     1.4     1.4
  132.21  138.79
Pier Skew, UpSta & Num, DnSta & Num=  ,4929.4, 2 ,4929.4, 2 , 0 , 0 , 0 ,,
     1.4     1.4
  131.06  142.64
     1.4     1.4
  131.06  142.64
Pier Skew, UpSta & Num, DnSta & Num=  ,4975.1, 2 ,4975.1, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   128.6  142.85
     1.4     1.4
   128.6  142.85
Pier Skew, UpSta & Num, DnSta & Num=  ,5024.2, 2 ,5024.2, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   126.3  143.09
     1.4     1.4
   126.3  143.09
Pier Skew, UpSta & Num, DnSta & Num=  ,5069.8, 2 ,5069.8, 2 , 0 , 0 , 0 ,,
     1.4     1.4
  132.34   143.3
     1.4     1.4
  132.34   143.3
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=156.66

Type RM Length L Ch R = 1 ,174137  ,480.7,271,262.9
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3016527.78      13913253.5      3020043.02     13910639.99
      3020608.33     13910212.19      3021876.59     13909310.65
#Sta/Elev= 30
   288.1  155.59   588.2  156.59   608.1  155.69   618.1  152.59   638.1  153.39
   658.2  147.19   668.1  147.69   688.2  142.39  1728.2  143.09  2018.1  140.19
  2288.2  141.59  2318.1  139.59  2718.2  141.59  3188.1  133.29  3668.2  132.59
  3738.1  134.49  3768.1  131.69  4118.1  130.49    4775  131.12 4937.23  133.57
 4975.13  129.94 4999.73     120 5048.23  132.92  5239.4  134.15  5997.5  143.39
  6027.6  140.29  6387.5  143.39  6837.6  143.19  6907.5  151.89    6934  152.19
#Mann= 7 ,-1 , 0
   288.1     .99       0  2718.2     .14       0    4775     .12       0
 4975.13    .045       0 5048.23      .2       0  5239.4     .14       0
  5997.5     .99       0
#XS Ineff= 2 , 0
       0 4723.18  143.68 5237.89       0  143.68
Permanent Ineff=
       F       F
Bank Sta=4975.13,5048.23
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,173866. ,372.2,276,326.3
BEGIN DESCRIPTION:
K100-00-00-S25A_PIPELINE -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3016562.13       13913437.      3020183.56     13910705.47
      3020377.87     13910709.77      3021707.69     13909474.02
#Sta/Elev= 30
   359.2  144.46   479.2  142.11   659.2  144.21  1279.2  140.67  1329.2  142.57
  1399.2  139.24  1549.2  142.36  2029.2  142.67  2359.2  139.18  2939.2  139.47
  3029.2  141.62  3519.2  136.84  3599.2  138.51  4069.2  137.49  4139.2  135.49
  4219.2  136.92  4269.2  129.89 4969.68  129.95 4975.61  129.65 4987.26  122.55
 5002.59  119.73 5033.01  130.99  5129.7  130.76  5189.7  135.44  5469.7  134.56
  5719.7  141.64  6359.7  141.77  6479.7  147.52  6729.7  149.44    6905  147.58
#Mann= 5 ,-1 , 0
   359.2     .99       0  3029.2     1.4       0 4969.68    .045       0
 5033.01     .24       0  5719.7     .99       0
#XS Ineff= 2 , 0
         4225.37  143.45
Permanent Ineff=
       F       F
Bank Sta=4969.68,5033.01
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,173590  ,1058.6,1252,849.8
BEGIN DESCRIPTION:
Cross Section Xs53.1
END DESCRIPTION:
XS GIS Cut Line= 6
      3016536.87      13913565.5      3020128.76      13910939.1
      3020192.87     13910965.12      3020278.01     13910989.45
      3020375.07     13911014.51      3021749.58     13909473.81
#Sta/Elev= 30
     442   141.6     592   143.7    1762   141.2    1832   142.6    2152   141.3
    2212     143    2772     139    3152   140.3    3232   143.5    3402     145
    3492   142.2    3682   138.4    4392     137    4442   130.3  4976.1  129.36
  4988.8  120.29  5005.5  119.46  5007.7  123.11  5017.5  129.02  5209.7   135.7
  5519.7   135.1  5649.7   137.2  5719.7   141.9  5849.7   143.2  6629.7   141.8
  6699.7   142.1  6849.7   148.4  6909.7   147.5  7109.7   150.6  7214.4   148.9
#Mann= 5 ,-1 , 0
     442     .99       0    3492     .14       0  4976.1    .045       0
  5017.5     .24       0  5849.7     .99       0
#XS Ineff= 2 , 0
         4228.37  143.38
Permanent Ineff=
       F       F
Bank Sta=4976.1,5017.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,172338  ,1803.3,1573,1179.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X53
END DESCRIPTION:
XS GIS Cut Line= 4
      3015893.23     13914734.46      3020417.11     13911968.17
      3020722.77     13911769.49      3021746.76     13909538.12
#Sta/Elev= 30
  -542.3   153.2  -472.3   153.1  -402.3   145.6  2577.7   142.6  3687.7   144.9
  3817.7   143.4  4067.7   135.3  4587.7   136.7  4647.7   135.3  4677.7   129.8
  4937.7  126.04  4976.1  128.11  4988.8  119.04  5005.5  118.21  5007.7  121.86
  5017.5  127.77  5092.6   126.1  5124.9   130.7  5234.9   136.3  5364.9   137.1
  5404.9   140.2  5484.9   141.2  6324.9   144.1  6524.9   140.9  6604.9   142.8
  7134.9   141.4  7204.9   142.1  7284.9   148.2  7444.9   148.4    7580   152.1
#Mann= 6 ,-1 , 0
  -542.3     .99       0  3687.7      .2       0  4976.1    .045       0
  5017.5     .24       0  5484.9      .2       0  6324.9     .99       0
Bank Sta=4976.1,5017.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,170765  ,225.2,180,242.2
BEGIN DESCRIPTION:
Cross Section Xs52.3
END DESCRIPTION:
XS GIS Cut Line= 6
      3021427.44      13916912.9      3021436.59     13913270.42
      3021607.87     13912568.04      3021643.78     13912446.86
      3021797.52     13911723.46      3021712.17     13909697.78
#Sta/Elev= 30
   560.3   144.1  1050.3   145.8  1200.3   141.6  1390.3   144.4  1560.3   140.6
  1740.3     147  1850.3   143.9  2810.3   144.1  3570.3   140.9  3930.3   136.8
  3960.3   138.7  3990.3   136.5  4522.8   136.4  4975.8   130.8  4980.7  122.64
  4999.7  117.19  5005.5  117.26  5017.4  125.63  5048.8  125.99  5052.2   128.7
  5262.2   129.4  5382.2   135.9  5512.2   136.1  5572.2   130.1  5712.2   129.4
  5801.7   141.1  6221.7   143.2  7451.7     144  7571.7   141.9  7819.2   149.4
#Mann= 6 ,-1 , 0
   560.3     .99       0  3570.3     .24       0  4975.8    .045       0
  5052.2     .24       0  5512.2      .2       0  6221.7     .99       0
#XS Ineff= 2 , 0
         4539.79  140.22 5508.65          140.22
Permanent Ineff=
       F       F
Bank Sta=4975.8,5052.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,170585  ,57.7,59,57.9
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3023065.17     13916505.28      3021674.38      13913280.5
      3021964.76     13911599.33      3021744.56     13909595.11
#Sta/Elev= 30
     738  143.51     898  141.81    1018  144.81    1268  141.61    1368  144.41
    1448  141.91    1608  143.71    1758  141.51    1988  144.41    3018  140.81
    3158  144.21    3218  141.61    3852  140.41    4098  137.11    4168  139.31
  4947.7   140.6  4966.9  125.54  4999.7  117.07  5005.5  117.14  5017.4  125.51
    5226  126.47  5255.2  130.59  5273.6  141.61  5627.6   141.4  5889.9  140.41
    6446  144.91    7656  141.61    7726  142.91    7826  149.61  7972.3  150.61
#Mann= 6 ,-1 , 0
     738     .99       0    3852     .24       0  4947.7    .045       0
  5273.6     .24       0  5627.6      .2       0    6446     .99       0
#XS Ineff= 2 , 0
       0 4941.18  140.44  5283.6       0  140.79
Permanent Ineff=
       F       F
Bank Sta=4947.7,5273.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,170558  ,,,
BEGIN DESCRIPTION:
BARKER-CYPRESS ROAD
Structure ID: K100-00-00-S116
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,34,2.6,0, 169, 169, , , .95, 0, ,,,
     738     798     828     868     878     898     918     928     948    1018
    1148    1168    1188    1268    1368    1418    1438    1448    1528    1608
    1718    1748    1758    1798    1988    2078    2098    2138    2208    2218
    2228    2248    2368    2408    2468    2508    2528    2578    2748    2778
    2788    2818    2868    2928    2988    3018    3038    3058    3088    3158
    3198    3218    3338    3378    3428    3648    3658    3808    3818    3828
    3838    3852    3858    3938    3948    3988    3998    4018    4038    4068
    4088    4098    4148    4168  4249.9  4289.9  4357.3  4367.3  4377.3  4417.3
  4457.3  4487.3  4507.3  4539.9  4597.3  4627.3  4669.9  4748.3  4797.3 4856.79
  4856.9 4857.01  4858.4  4946.8  4946.9 4947.01  4947.2  4947.3  4947.7  4966.9
  4980.7  4991.7  4992.8  4995.1  4999.7  5005.5  5008.3  5012.2  5017.4  5041.5
  5048.8  5077.2  5103.3  5108.8  5108.9  5141.8  5161.3  5183.1  5207.3  5219.9
    5226  5255.2    5272 5272.09  5272.2  5273.6 5421.19  5421.3 5421.41  5422.3
  5477.3  5480.9  5498.9  5507.3  5519.9  5569.9  5587.3  5627.6  5707.3  5727.3
  5739.9  5749.1  5889.9  5949.9  5955.3    5956    6096    6126    6446    6516
    6856    6866    7226    7266    7416    7596    7646    7656    7676    7696
    7716    7726    7806    7816    7826    7876    7956  7972.2  7972.3
   143.5   144.1   143.3   143.4   143.2   141.8   141.9   142.2   143.9   144.8
   143.9   143.3   141.7   141.6   144.4   144.1   142.9   141.9   141.7   143.7
   142.9   141.5   141.5   143.9   144.4   143.8   143.3   143.3   142.2   141.8
   142.2   141.6   141.3   141.8     142   140.8   140.9     143     142   141.3
   141.6   140.9   140.8     141   141.8   140.8   141.1   142.8   143.9   144.2
   142.7   141.6   141.1   142.5   142.3   141.2   140.9   141.1   141.9   142.1
   141.8   140.4   139.8   138.2   137.7   139.1     139   137.6   137.4   138.2
   137.7   137.1   138.3   139.3   139.4   138.7  138.93  138.96  138.99  139.12
  139.25  139.34  139.41  139.51  139.42  139.38  139.47  140.95  141.77  142.91
  145.01  145.01  145.04  146.55  146.51  146.51  146.51  146.51  146.51  146.52
  146.52  146.53  146.53  146.53  146.54  146.56  146.57  146.58   146.6  146.68
   146.7   146.7   146.7   146.7   146.7  146.67  146.66   146.6  146.54  146.51
  146.47   146.3   146.2   146.2   146.2  146.19  145.32  145.32  143.22  143.21
  143.12  143.15  142.66   142.8  142.67  142.17     142  141.46  140.98  140.88
  140.81  140.79  140.97  141.41   141.4   141.2   142.3   141.7   144.9   142.9
   142.9   143.4   143.1   143.1   142.9   143.4   141.7   141.6   142.7     143
   142.7   142.9   148.1   149.1   149.6   148.9   149.5  150.59   150.6
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                          142.11  142.11  142.12
  142.12  142.13  142.13  142.13  142.14  142.16  142.17  142.18   142.2  142.28
   142.3   142.3   142.3   142.3   142.3  142.27  142.26   142.2  142.14  142.11
  142.07   141.9   141.8   141.8
                                                                                
                                                                                
                                                                                
                                                                        
     738     798     828     868     878     898     918     928     948    1018
    1148    1168    1188    1268    1368    1418    1438    1448    1528    1608
    1718    1748    1758    1798    1988    2078    2098    2138    2208    2218
    2228    2248    2368    2408    2468    2508    2528    2578    2748    2778
    2788    2818    2868    2928    2988    3018    3038    3058    3088    3158
    3198    3218    3338    3378    3428    3648    3658    3808    3818    3828
    3838    3852    3858    3938    3948    3988    3998    4018    4038    4068
    4088    4098    4148    4168  4249.9  4289.9  4357.3  4367.3  4377.3  4417.3
  4457.3  4487.3  4507.3  4539.9  4597.3  4627.3  4669.9  4748.3  4797.3 4856.79
  4856.9 4857.01  4858.4  4946.8  4946.9 4947.01  4947.2  4947.3  4947.7  4966.9
  4980.7  4991.7  4992.8  4995.1  4999.7  5005.5  5008.3  5012.2  5017.4  5041.5
  5048.8  5077.2  5103.3  5108.8  5108.9  5141.8  5161.3  5183.1  5207.3  5219.9
    5226  5255.2    5272 5272.09  5272.2  5273.6 5421.19  5421.3 5421.41  5422.3
  5477.3  5480.9  5498.9  5507.3  5519.9  5569.9  5587.3  5627.6  5707.3  5727.3
  5739.9  5749.1  5889.9  5949.9  5955.3    5956    6096    6126    6446    6516
    6856    6866    7226    7266    7416    7596    7646    7656    7676    7696
    7716    7726    7806    7816    7826    7876    7956  7972.2  7972.3
   143.5   144.1   143.3   143.4   143.2   141.8   141.9   142.2   143.9   144.8
   143.9   143.3   141.7   141.6   144.4   144.1   142.9   141.9   141.7   143.7
   142.9   141.5   141.5   143.9   144.4   143.8   143.3   143.3   142.2   141.8
   142.2   141.6   141.3   141.8     142   140.8   140.9     143     142   141.3
   141.6   140.9   140.8     141   141.8   140.8   141.1   142.8   143.9   144.2
   142.7   141.6   141.1   142.5   142.3   141.2   140.9   141.1   141.9   142.1
   141.8   140.4   139.8   138.2   137.7   139.1     139   137.6   137.4   138.2
   137.7   137.1   138.3   139.3   139.4   138.7  138.93  138.96  138.99  139.12
  139.25  139.34  139.41  139.51  139.42  139.38  139.47  140.95  141.77  142.91
  145.01  145.01  145.04  146.55  146.51  146.51  146.51  146.51  146.51  146.52
  146.52  146.53  146.53  146.53  146.54  146.56  146.57  146.58   146.6  146.68
   146.7   146.7   146.7   146.7   146.7  146.67  146.66   146.6  146.54  146.51
  146.47   146.3   146.2   146.2   146.2  146.19  145.32  145.32  143.22  143.21
  143.12  143.15  142.66   142.8  142.67  142.17     142  141.46  140.98  140.88
  140.81  140.79  140.97  141.41   141.4   141.2   142.3   141.7   144.9   142.9
   142.9   143.4   143.1   143.1   142.9   143.4   141.7   141.6   142.7     143
   142.7   142.9   148.1   149.1   149.6   148.9   149.5  150.59   150.6
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                          142.11  142.11  142.12
  142.12  142.13  142.13  142.13  142.14  142.16  142.17  142.18   142.2  142.28
   142.3   142.3   142.3   142.3   142.3  142.27  142.26   142.2  142.14  142.11
  142.07   141.9   141.8   141.8
                                                                                
                                                                                
                                                                                
                                                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,5012.2, 2 ,5012.2, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  120.99  143.18
     1.5     1.5
     121  143.19
Pier Skew, UpSta & Num, DnSta & Num=  ,5077.2, 2 ,5077.2, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  125.11   143.3
     1.5     1.5
  125.12  143.31
Pier Skew, UpSta & Num, DnSta & Num=  ,5141.8, 2 ,5141.8, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  124.92  143.27
     1.5     1.5
  124.93  143.28
Pier Skew, UpSta & Num, DnSta & Num=  ,5207.3, 2 ,5207.3, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  125.03  143.14
     1.5     1.5
  125.04  143.15
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=150.61

Type RM Length L Ch R = 1 ,170526  ,139.3,125,135
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3023119.56     13916510.14      3021731.13     13913290.81
      3022020.98     13911612.73      3021800.47      13909605.7
#Sta/Elev= 30
     738   143.5     898   141.8    1018   144.8    1268   141.6    1368   144.4
    1448   141.9    1608   143.7    1758   141.5    1988   144.4    3018   140.8
    3158   144.2    3218   141.6    3852   140.4    4098   137.1    4168   139.3
  4947.7  140.59  4966.9  125.53  4999.7  117.06  5005.5  117.13  5017.4   125.5
    5226  126.46  5255.2  130.58  5273.6   141.6  5627.6  141.39  5889.9   140.4
    6446   144.9    7656   141.6    7726   142.9    7826   149.6  7972.3   150.6
#Mann= 6 ,-1 , 0
     738     .99       0    3852     .24       0  4947.7    .045       0
  5273.6     .24       0  5627.6      .2       0    6446     .99       0
#XS Ineff= 2 , 0
       0 4941.18  140.59 5280.27       0  140.79
Permanent Ineff=
       F       F
Bank Sta=4947.7,5273.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,170401. ,577.8,397,273.5
BEGIN DESCRIPTION:
K100-00-00-S116_BARKER-CYPRESS -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3023147.71      13916490.8      3021869.87     13913345.47
      3022097.97     13911646.15      3021869.87       13909599.
#Sta/Elev= 30
   853.6  143.69   963.6  140.93  1213.6  144.59  1633.6  141.71  2013.6  144.47
  2183.6  141.53  2283.6  144.28  2663.6   141.4  2943.6  144.12  3093.6  140.62
  3223.6  144.47  3693.6  141.32  3743.6   140.6  3823.6  128.87  3873.6  128.68
  3923.6  137.53  3953.6  138.35 4903.03  139.16 4903.71  139.16 4939.15  126.15
  4999.7  116.97 5015.68  124.25 5040.76  126.75  5288.7  128.95  5338.7  135.63
  5478.7   139.7  6243.2  141.55  6723.2  144.96  7753.2  141.18  8023.1  148.35
#Mann= 6 ,-1 , 0
   853.6     .99       0  3693.6     .28       0 4903.03     .12       0
 4903.71    .045       0  5478.7      .2       0  6243.2     .24       0
#XS Ineff= 2 , 0
         4709.22  139.49
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
 3680.85 3943.26  138.19
Bank Sta=4903.71,5478.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,170004  ,547.8,1390,1229.6
BEGIN DESCRIPTION:
Cross Section XS52.2
END DESCRIPTION:
XS GIS Cut Line= 4
      3023185.09      13916549.7      3022283.24     13912393.85
      3022247.47     13912338.82      3021945.07      13909533.7
#Sta/Elev= 30
     724   144.8     944   141.7    1884   144.9    2064   141.2    2274   143.9
    2364   139.4    2574     144    2694   140.4    3114   141.2    3174     131
    3624   128.3    3664   135.5    3704     137    4324   133.1    4764   134.6
    4804   128.3  4966.9  125.16  4999.7  116.69  5005.5  116.76  5026.7   129.7
  5036.7   131.2  5162.3   136.6  5712.3     143  5762.3   140.4  6122.3   140.1
  6422.3   145.5  6612.3   142.7  6972.3   145.6  7582.3   141.7  7863.7   148.5
#Mann= 6 ,-1 , 0
     724     .99       0    3114     .05       0    3704     .24       0
    4764   .0525       0  5162.3      .2       0  5712.3     .99       0
#XS Ineff= 2 , 0
         3979.24  140.09
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
    3115 3704.01     137
Bank Sta=4764,5162.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,168614  ,1381.4,1022,551.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X52A
END DESCRIPTION:
XS GIS Cut Line= 4
      3023259.81     13916599.03      3022984.71     13912885.17
      3023366.79     13912365.54      3022205.26     13909324.15
#Sta/Elev= 30
    1010     145    1280   142.1    1340   144.2    1880   142.1    1980   144.5
    2400   141.5    2890   144.1    3350   141.8    3399   137.4    3470   128.2
    3800     128    3870   122.8    3940   135.6  3973.2  136.11    4814   131.5
  4885.4  140.18  4962.4   128.2  4965.6  127.65  4967.6  120.23  5000.3  115.69
  5007.9  116.24  5020.8  126.45  5038.2  135.14  5174.8  135.29    5849     140
    5939   133.7    6019   141.1    6109   142.2    8459     143  8634.7   148.8
#Mann= 8 ,-1 , 0
    1010     .99       0    3399     .05       0  3973.2     .24       0
  4885.4     .09       0  4962.4   .0525       0  5038.2     .24       0
  5174.8      .2       0    5849     .99       0
#Block Obstruct= 2 ,-1
    3400  3969.3  136.21  5808.9    6018  140.72
Bank Sta=4885.4,5038.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,167592  ,884.8,594,374.6
BEGIN DESCRIPTION:
Cross Section Xs52.1
END DESCRIPTION:
XS GIS Cut Line= 4
      3025360.88      13915138.3      3024098.57     13912553.43
      3024041.46     13912433.49      3022244.46     13909171.41
#Sta/Elev= 30
  2069.4   143.3  2419.4   143.6  2529.4   126.3  2609.4   142.8  2629.4   143.9
  3349.4   142.8  3669.4   138.9  3859.4   133.1  4099.4   134.1  4449.4   131.3
  4929.4   135.4  4946.1   134.2  4999.6   115.1  5006.2  115.25  5010.1  122.57
  5018.8  127.51  5046.1   128.4  5098.9   137.8  5198.9     138  5268.9   134.7
  5558.9   135.3  6188.9   142.1  6728.9   141.5  6798.9   134.3  6858.9     141
  7338.9   140.5  7808.9   144.1  8538.9   141.4  8738.9     150  8803.2   150.3
#Mann= 6 ,-1 , 0
  2069.4     .99       0  3349.4     .16       0  4099.4     .24       0
  4929.4   .0525       0  5098.9      .2       0  6188.9     .99       0
#Block Obstruct= 2 ,-1
  2419.4    2628   143.6    6729  6858.9     141
Bank Sta=4929.4,5098.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,166998  ,517.6,519,513.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X52
END DESCRIPTION:
XS GIS Cut Line= 4
      3025949.68     13914673.33       3025017.4     13912487.81
      3024161.53     13911891.76      3022321.77     13909047.46
#Sta/Elev= 30
  2049.1   140.7  2999.1   138.9  3159.1   142.5  3329.1   138.9  3469.1   141.6
  3569.1   136.5  3859.1   136.1    3874  133.33  3889.1   130.4  4338.9  133.18
  4785.2   130.6  4862.4  137.64  4965.8  127.82  4999.6  114.76  5006.2  114.91
  5010.1  122.23  5027.2  134.43  5043.6  136.82  5062.2  136.85  5065.2   130.3
  5155.2   137.9  5355.2   134.2  6148.1   140.8  7108.1   141.6  7188.1   134.3
  7248.1   141.2  7748.1   143.9  8018.1     140  8678.1   141.6  8855.6   147.4
#Mann= 8 ,-1 , 0
  2049.1     .99       0  3469.1     .24       0    3874     .05       0
  4338.9     .24       0  4965.8   .0525       0  5027.2     .24       0
  5043.6      .2       0  6148.1     .99       0
#Block Obstruct= 2 ,-1
    3862  4299.2  133.19    7137    7232  140.92
Bank Sta=4965.8,5027.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,166479  ,909.5,1490,1217.9
BEGIN DESCRIPTION:
Cross Section XS51.2
END DESCRIPTION:
XS GIS Cut Line= 4
      3026409.58     13914477.14      3025420.96     13912159.56
      3024527.96     13911537.64       3022741.6      13908775.9
#Sta/Elev= 30
  1637.1  141.97  1867.1  143.12  1937.1  139.51  2087.1  142.35  2227.1  139.74
  2407.1  142.67  2687.1  139.77  2727.1  142.14  2897.1   142.6  2977.1  139.96
  3257.1  141.74  3767.1  134.68  4416.7  135.22  4466.7  134.08  4516.7  129.42
  4546.7  135.49  4566.7  136.09  4616.7   133.3  4766.7  134.23  4966.7   131.1
  5017.1   114.7  5023.4   117.1  5027.2   122.7  5043.7   133.8  5166.7  132.98
  5186.7  134.74    5425  134.82    5465  137.35    6165   141.3  8534.1  142.88
#Mann= 3 ,-1 , 0
  1637.1      .2       0  4966.7   .0525       0  5043.7     .24       0
Bank Sta=4966.7,5043.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,164989  ,815.4,1032,980.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X51
END DESCRIPTION:
XS GIS Cut Line= 4
      3026958.38     13913955.01      3026240.06     13911723.64
        3025751.     13911219.29      3023466.69     13907473.18
#Sta/Elev= 30
  2272.7   140.5  2422.7   144.4  4362.7   140.3  4592.7   138.7  4826.8   129.8
    4956     130    4969   124.9  4979.3  124.59  4991.9  116.64  5009.6   114.5
  5014.9  123.09  5033.6  131.95  5116.8   129.4  5216.8   136.2  5256.8   132.8
  5379.4   132.3  6459.3  138.41  6769.4   139.7  7109.4   141.8  7169.4   137.7
  7199.4     142  7659.4   139.9  8629.4   143.2  9239.4   142.9  9379.4   140.2
  9469.4   145.2  9569.4   141.1  9609.4   144.2  9659.4   140.6    9707   143.1
#Mann= 6 ,-1 , 0
  2272.7     .99       0  4362.7     .24       0    4956   .0525       0
  5033.6     .24       0  6459.3      .2       0  6769.4     .99       0
Bank Sta=4956,5033.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,163957  ,1298.9,1510,1398.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X50
END DESCRIPTION:
XS GIS Cut Line= 4
      3027646.13     13913572.92      3026897.25     13911341.55
      3026591.58      13910745.5      3024360.21     13906848.25
#Sta/Elev= 30
  2296.2   144.1  2536.2   141.7  3066.2   143.6  3606.2   141.2  3836.2   143.6
  4246.2   140.3  4326.2   142.5  4436.2   141.3  4769.9     137  4819.9   133.9
  4909.9   133.8  4934.7  130.98  4942.1  128.14  4983.5  121.44  4990.1  116.81
  4999.4  114.24  5008.6  117.61  5013.8  122.79  5029.2  131.69  5289.9   128.8
  5502.9  129.88  6179.7   134.2  6769.7   134.2  7209.7   139.3  8319.7   141.1
  8909.7   139.5  9409.7   140.9  9479.7   139.2  9629.7   144.7  9810.6   140.4
#Mann= 6 ,-1 , 0
  2296.2     .99       0  4436.2     .24       0  4934.7   .0525       0
  5029.2     .24       0  5502.9      .2       0  7209.7     .99       0
Bank Sta=4934.7,5029.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,162447  ,1461.4,1669,1273.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X49
END DESCRIPTION:
XS GIS Cut Line= 4
      3028104.63     13913420.09      3028012.93     13910776.07
      3027798.97     13910057.75      3025430.05      13905885.4
#Sta/Elev= 30
    1892   141.7    3542   141.9    4252   138.7  4647.6     130  4797.6   128.6
  4937.6     132  4977.7  128.06  4986.4  118.84  4998.9  113.97  5065.5  130.21
  5884.3  132.59  7117.1   136.8  7217.1   139.1  7327.1   136.7  7437.1     136
  7497.1   138.9  7537.1   135.6  7757.1   138.2  8267.1     137  9297.1   140.1
  9587.1     140  9627.1   138.1  9677.1   138.5  9697.1     142  9777.1   143.4
  9847.1   140.8  9867.1   143.5  9937.1   139.1  9967.1   141.3 10085.1   139.6
#Mann= 6 ,-1 , 0
    1892     .99       0    3542     .24       0  4977.7    .045       0
  5065.5     .24       0  5884.3      .2       0  7327.1     .99       0
Bank Sta=4977.7,5065.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,160778  ,100.5,427,770.9
BEGIN DESCRIPTION:
Cross Section XS48.7
END DESCRIPTION:
XS GIS Cut Line= 6
      3028388.67      13913496.9      3029307.69     13909623.38
        3029184.     13909548.09      3029019.58     13909454.14
      3028681.85     13909286.11      3026539.18     13904944.57
#Sta/Elev= 30
   810.8   142.3   980.8   140.7  2070.8   141.3  3510.8   138.6  4190.8   137.2
  4250.8   132.8  4380.8   131.9  4420.8   133.8  4610.8   130.6  4791.9   131.3
  4956.7   124.2  4966.7     123  4969.5  117.53    5011  113.49  5038.6  126.89
  5306.1   128.2  5416.1   131.5  6563.3   133.4  7183.3   137.2  7843.3   136.1
  7903.3   137.3  9793.3   137.5  9953.3   141.8 10023.3   140.5 10043.3   141.7
 10093.3   140.4 10113.3   138.1 10173.3   140.1 10263.3   137.9 10344.8   138.7
#Mann= 8 ,-1 , 0
   810.8     .99       0  3510.8     .16       0  4190.8     .24       0
  4791.9    .045       0  5038.6     .12       0  5416.1     .24       0
  6563.3      .2       0  7903.3     .99       0
#XS Ineff= 2 , 0
         4364.58  137.19 6427.08          137.42
Permanent Ineff=
       F       F
Bank Sta=4791.9,5038.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,160351. ,115.7,106,104.5
BEGIN DESCRIPTION:
K100-00-00-S23_TELGE RD -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3028464.82      13913455.2      3029413.32     13909557.41
      3029368.14     13908871.54      3029015.02     13903628.05
#Sta/Elev= 30
   675.9  142.05  2775.9  140.18  3305.9  138.45  3475.9  135.06  3565.9  138.12
  3785.9  137.62  4015.9  137.26  4105.9  133.99  4285.9  135.74  4505.9   130.2
  4937.5  128.43 4963.58  118.96    5011  113.36  5037.5   127.6  5057.5  129.94
  5247.5  131.13  5814.8  132.81  6194.8  130.33  7034.8  134.85  7714.8   136.8
  7754.8  134.98  7834.8  137.83  8624.8   135.5  9064.8  138.04  9244.8  134.81
  9864.8  139.12 10414.8   136.2 10504.8  138.41 10584.8  154.47 10630.2  156.12
#Mann= 6 ,-1 , 0
   675.9     .99       0  3785.9      .2       0  4105.9     .24       0
  4937.5    .045       0  5037.5     .24       0  7034.8      .2       0
#XS Ineff= 2 , 0
        4798.526137.00585358.915        137.1236
Permanent Ineff=
       F       F
Bank Sta=4937.5,5037.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,160245  ,112.4,97,104.4
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3028567.86     13913448.15      3029516.36     13909550.31
      3029471.18     13908864.43      3029118.06     13903620.95
#Sta/Elev= 30
   681.8  142.36  2761.8  140.21  4401.8  134.59  4621.8  130.24  4693.4  135.06
  4883.4  135.62  4913.4  133.81  4951.1  126.66  4969.5  117.37    5011  113.33
  5038.6  126.73  5053.4  127.64  5083.4  136.48  5440.7  130.53  5510.7   132.5
  5950.7   130.2  6520.7   132.8  6570.7  130.73  6640.7   133.7  7020.7   135.4
  7770.7  135.18  7830.7  137.44  8330.7  138.06  9080.7  134.86  9720.7  139.24
 10480.7  136.12 10580.7  138.49 10620.7  147.31 10630.7  147.66 10636.1  145.06
#Mann= 6 ,-1 , 0
   681.8     .99       0  4401.8     .24       0  4883.4   .0188       0
  5083.4     .24       0  6520.7      .2       0  7020.7     .99       0
#XS Ineff= 2 , 0
       0  4883.4  136.96 5093.75       0  137.05
Permanent Ineff=
       F       F
Bank Sta=4883.4,5083.4
XS Rating Curve= 0
Exp/Cntr=.5,.3
