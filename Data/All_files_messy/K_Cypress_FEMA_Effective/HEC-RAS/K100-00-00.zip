HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,181664  ,395.57,321.67,141.64
BEGIN DESCRIPTION:
Interpolated Cross Section
END DESCRIPTION:
XS GIS Cut Line= 5
   3014598.09309  13912454.60433   3015502.52611  13908964.25717
   3015757.29598  13908289.11703   3015761.10722  13902784.48446
   3015761.15331  13902776.82284
#Sta/Elev= 30
  985.78   145.7 1547.08   146.2 2748.89   141.6 2821.77   142.3 3380.36     139
  3755.5   139.6 4040.55     138 4085.17   131.5 4182.81   131.6 4230.02  137.65
    4348   137.9 4406.36   139.6 4523.13   138.6 4792.36   140.5 4851.22   137.8
 4920.81   139.3 4963.64  135.07 4982.42  131.98 4989.42  124.44 4999.86  123.14
 5011.82  125.09 5031.61  133.44 5050.87   135.1 5128.94   139.6 5337.72   137.4
 5506.26   139.6 6153.47   141.1 6400.88   142.9 7393.33   143.510825.31   142.9
#Mann= 6 ,-1 , 0
  985.78     .24       0  3755.5     .04       0 4406.36     .24       0
 4963.64    .075       0 5050.87     .24       0 7393.33     .99       0
#XS Ineff= 1 ,-1
 4040.55 4348.02   137.9
Permanent Ineff=
       T
Bank Sta=4963.64,5050.87
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,181342  ,133,132.88,133
BEGIN DESCRIPTION:
Cut using LiDAR Data and topographic field survey data (Imported from CLOMR proposed Model)
END DESCRIPTION:
XS GIS Cut Line= 4
   3015177.97678  13911601.96652   3015709.79887  13910393.61691
   3016644.64892  13903076.32886   3016663.97229  13902806.06618
#Sta/Elev= 30
 2020.13   144.1 2220.43   144.2 2277.81   142.8 2626.45     142 3024.66   141.8
 3102.07   140.6  3648.4   138.4 4312.16   139.8 4723.96   137.8 4841.78   139.9
 4912.19   139.1 4952.87   140.1 4957.74   139.7 4958.61  135.11 4980.07   133.6
 4988.07   124.5    5000   122.9 5011.67   124.9 5034.72  132.24 5035.83   134.6
 5050.65   135.1 5202.98     140 5314.17   137.6 5388.52   137.6 5459.17   138.9
 6146.65   142.2  6968.4   143.8 8763.38   143.2 9321.97   143.910988.05   142.4
#Mann= 4 ,-1 , 0
 2020.13     .24       0 4958.61    .075       0 5050.65     .24       0
 8763.38     .99       0
#XS Ineff= 2 , 0
       0 3873.93  143.76 5672.24       0   143.4
Permanent Ineff=
       T       T
Bank Sta=4958.61,5050.65
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,181273.6,,,
BEGIN DESCRIPTION:
Proposed Greenhouse Road
END DESCRIPTION:
Node Name=Proposed Greenho
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
49.8,37,2.6,0, 33, 33, , , .95, 0, 0,0,,
 2020.13 3388.13 3409.133459.129 3509.13 3559.133609.129 3659.133709.129 3759.13
 3809.133835.6293873.629 3873.934779.069 5672.245673.959 5747.13 5797.135847.129
5897.129 5947.135997.129 6047.136097.1296147.129 6197.136247.129 6297.13 6347.13
6397.129 6432.3310734.25
     144   143.8  143.76  143.89  144.35  145.11   146.2  147.56  148.95  150.04
  150.73  150.91  150.91  154.41  157.13  154.41  150.91  150.43  149.89  148.95
  147.64   146.4  145.48  144.88  144.59  144.44  144.29  144.13  143.98  143.82
  143.67  143.56   143.4
                                                                                
                          144.87  144.87  144.87
                                                                                
                        
 2042.983434.979 3455.983505.979 3555.98 3605.98 3655.98 3705.983755.979 3805.98
3855.9793882.479 3925.83 3926.13 4831.27 5725.82 5726.16 5786.985836.979 5886.98
5936.9795986.979 6036.986086.9796136.9796186.9796236.979 6286.98 6336.98 6386.98
 6436.98 6472.1810789.09
     144   143.8  143.76  143.89  144.35  145.11   146.2  147.56  148.95  150.04
  150.73  150.91  150.91  153.33  156.05  153.33  150.91  150.43  149.89  148.95
  147.64   146.4  145.48  144.88  144.59  144.44  144.29  144.13  143.98  143.82
  143.67  143.56   143.4
                                                                                
                          144.87  144.87  144.87
                                                                                
                        
Pier Skew, UpSta & Num, DnSta & Num=  ,3929.89, 2 ,3982.09, 2 , 0 , 0 , 0 ,,
       3       3
   86.87  144.87
       3       3
   86.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4019.89, 2 ,4072.09, 2 , 0 , 0 , 0 ,,
       3       3
   70.87  144.87
       3       3
   70.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4139.89, 2 ,4192.09, 2 , 0 , 0 , 0 ,,
       3       3
   67.87  144.87
       3       3
   67.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4259.89, 2 ,4312.089, 2 , 0 , 0 , 0 ,,
       3       3
   67.87  144.87
       3       3
   67.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4379.89, 2 ,4432.09, 2 , 0 , 0 , 0 ,,
       3       3
   67.87  144.87
       3       3
   67.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4499.89, 2 ,4552.09, 2 , 0 , 0 , 0 ,,
       3       3
   74.87  144.87
       3       3
   74.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4619.89, 2 ,4672.089, 2 , 0 , 0 , 0 ,,
       3       3
   75.87  144.87
       3       3
   75.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4739.89, 2 ,4792.09, 2 , 0 , 0 , 0 ,,
       3       3
   60.87  144.87
       3       3
   60.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4840.709, 2 ,4892.91, 2 , 0 , 0 , 0 ,,
       3       3
   60.87  144.87
       3       3
   60.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,4941.53, 2 ,4993.73, 2 , 0 , 0 , 0 ,,
       3       3
   61.87  144.87
       3       3
   61.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,5042.35, 2 ,5094.549, 2 , 0 , 0 , 0 ,,
       3       3
   76.87  144.87
       3       3
   76.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,5132.77, 2 ,5184.97, 2 , 0 , 0 , 0 ,,
       3       3
   61.87  144.87
       3       3
   61.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,5252.769, 2 ,5304.971, 2 , 0 , 0 , 0 ,,
       3       3
   64.87  144.87
       3       3
   64.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,5343.04, 2 ,5395.24, 2 , 0 , 0 , 0 ,,
       3       3
   66.87  144.87
       3       3
   66.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,5433.96, 2 ,5486.16, 2 , 0 , 0 , 0 ,,
       3       3
   79.87  144.87
       3       3
   79.87  144.87
Pier Skew, UpSta & Num, DnSta & Num=  ,5553.959, 2 ,5606.159, 2 , 0 , 0 , 0 ,,
       3       3
   66.87  144.87
       3       3
   66.87  144.87
Abutment Skew #Up #Dn= , 2 , 2
 3873.93 3894.54
  144.87     138
 3926.13 3946.13
  144.87     138
Abutment Skew #Up #Dn= , 2 , 2
 5651.62 5672.24
     138  144.87
  5705.2 5725.82
     138  144.87
BR Coef=-1 , 1 , 0 ,, 0 ,,,.8,0,1.2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 30
 2020.13   144.1 2220.43   144.2 2277.81   142.8 2626.45     142 3024.66   141.8
 3102.07   140.6  3648.4   138.4 4312.16   139.8 4723.96   137.8 4841.78   139.9
 4912.19   139.1 4952.87   140.1 4957.74   139.7 4958.61  135.11 4980.07   133.6
 4988.07   124.5    5000   122.9 5011.67   124.9 5034.72  132.24 5035.83   134.6
 5050.65   135.1 5202.98     140 5314.17   137.6 5388.52   137.6 5459.17   138.9
 6146.65   142.2  6968.4   143.8 8763.38   143.2 9321.97   143.910988.05   142.4
BR U #Mann= 4
 2020.13     .04 4958.61    .075 5050.65     .04 8763.38     .99
BR D #Sta/Elev= 30
 2042.98   144.6 2551.54   142.5 2612.54   143.2 3024.71   140.7  3245.3   140.8
 3811.06   138.2  4068.6   139.3 4553.38   138.9  4690.6   137.7    4731   136.5
 4772.39   136.5 4916.08     142 4961.66   140.2  4979.2     139 4979.36     135
 4992.06  124.86    5000  122.62 5010.42  124.93 5045.94  140.15 5115.86   140.6
 5138.94   143.2 5209.45   140.5 5246.63   137.7 5277.03   137.5 6251.18   142.7
 6786.44   143.6 8805.68   143.310243.16   143.610549.71   142.511091.19   142.4
BR D #Mann= 4
 2042.98     .04 4961.66    .075 5045.94     .04 8805.68     .99
BC Design=,, 0 ,, 0 ,,,,,,

Type RM Length L Ch R = 1 ,181209  ,20.5,150.59,235.63
BEGIN DESCRIPTION:
Cut using LiDAR Data and topographic field survey data (Imported from CLOMR proposed Model)
END DESCRIPTION:
XS GIS Cut Line= 4
   3015271.58316  13911683.02016    3015809.8206   13910460.0938
   3016742.25852  13903161.68832   3016785.66535  13902810.00517
#Sta/Elev= 30
 2042.98   144.6 2551.54   142.5 2612.54   143.2 3024.71   140.7  3245.3   140.8
 3811.06   138.2  4068.6   139.3 4553.38   138.9  4690.6   137.7    4731   136.5
 4772.39   136.5 4916.08     142 4961.66   140.2  4979.2     139 4979.36     135
 4992.06  124.86    5000  122.62 5010.42  124.93 5045.94  140.15 5115.86   140.6
 5138.94   143.2 5209.45   140.5 5246.63   137.7 5277.03   137.5 6251.18   142.7
 6786.44   143.6 8805.68   143.310243.16   143.610549.71   142.511091.19   142.4
#Mann= 4 ,-1 , 0
 2042.98     .24       0 4961.66    .075       0 5045.94     .24       0
 8805.68     .99       0
#XS Ineff= 2 , 0
       0 3926.13  143.76 5725.82       0   143.4
Permanent Ineff=
       F       F
Bank Sta=4961.66,5045.94
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,181058  ,340,507.89,374.37
BEGIN DESCRIPTION:
Interpolated Cross Section
END DESCRIPTION:
XS GIS Cut Line= 6
   3014988.33841    13912347.614   3015854.55596  13910436.84001
   3016020.15637  13909188.46767   3016211.23377   13908742.6204
   3016954.51771  13903527.03477   3017011.33923  13902817.33924
#Sta/Elev= 30
 1355.74   145.3 1701.62   144.3 1839.04   145.3 1909.72   144.2 2097.92     145
 2594.49   142.1 2840.93     143 2921.79   141.2  3143.7   141.5 3822.11   138.2
 4573.45   138.9 4646.29   138.4 4705.45   136.5 4806.62     138 4952.64     136
 4976.94  134.96 4995.55  126.67 5007.18  122.85 5051.46  137.13 5086.36   139.7
 5168.13   137.5 5277.91   137.5 5374.95   139.7 5686.68   137.7 6165.88   142.1
 6924.14   144.1 8806.12   143.2  9823.9   143.810061.73   142.311178.33   142.5
#Mann= 4 ,-1 , 0
 1355.74     .24       0 4952.64    .075       0 5051.46     .24       0
 8806.12     .99       0
Bank Sta=4952.64,5051.46
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,180551  ,2203.5,1916,998.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X55
ROB spills out of watershed.
END DESCRIPTION:
XS GIS Cut Line= 5
      3014117.62     13914472.83      3016342.64     13909417.46
       3016440.8     13909302.94   3017484.14774  13904607.88013
   3017662.35988  13902838.42822
#Sta/Elev= 30
  -616.8   150.5  -536.8     148  -186.8     147  1153.2   147.2  1253.2   145.3
  2393.2   144.5  3893.2   139.4  4917.8  138.87    4970  138.36  4986.4  133.67
  4997.7  135.06  5027.8   123.5  5067.3  140.01  5085.2  141.11  5297.4   138.8
  5677.4   138.7  5767.4   136.9  5977.4   138.4  6517.4   137.9  6847.4   142.2
  8877.4   143.2  8937.4   144.8  8967.4   142.6  8997.4   143.5 9884.14   143.2
 9970.07   144.210105.51   142.4 10705.4   142.810737.89   143.711645.38   142.2
#Mann= 6 ,-1 , 0
  -616.8     .99       0  2393.2     .28       0  4917.8      .2       0
    4970    .075       0  5067.3     .28       0  8937.4     .99       0
Bank Sta=4970,5067.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,178635  ,1581.5,1862,1678.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X54
END DESCRIPTION:
XS GIS Cut Line= 4
      3014176.52     13914416.91       3017824.5     13910788.14
      3017520.24     13909960.39      3017733.28     13905196.47
#Sta/Elev= 30
  -915.2   149.9  -675.2   147.3   -55.2   148.1  2414.8   143.6  4044.8     137
  4790.3     138  4910.3   141.5  4944.3  137.78  4968.7  134.31  4976.7  132.25
    4986  125.55  5000.1  124.38  5008.1  124.38  5023.3  130.89  5030.7  131.56
  5041.9  139.53  5192.1   137.5  5602.1   137.4  6662.1   141.6  7642.1     141
  7802.1   144.3  8192.1     143  8272.1   143.7  8422.1   150.4  8502.1   150.9
  8802.1   148.6  8842.1   142.7  8942.1   142.8    8992   145.8  9880.8   144.2
#Mann= 5 ,-1 , 0
  -915.2     .99       0  2414.8     .28       0  4944.3     .06       0
  5041.9     .28       0  6662.1     .99       0
#XS Ineff= 2 , 0
       0 3024.22   146.5               0
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
    5000  5000.1      50    8817    8992  145.81
Bank Sta=4944.3,5041.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,176773  ,625.7,1509,1558.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X54A
END DESCRIPTION:
XS GIS Cut Line= 4
      3014283.86     13914337.73      3019083.01     13909877.19
      3019069.93     13909209.68      3021250.77      13904689.3
#Sta/Elev= 30
 -2097.4   149.9  -154.1  145.88  2782.6   137.8  3402.6   139.5  3682.6   134.8
  4342.6   139.1  4491.7  134.29  4524.6   130.1  4754.6   130.2  4897.8  134.28
  4939.3  127.66  4981.3  130.47  4987.2  123.75  4999.2  122.47  5012.9  124.84
  5026.2  132.82  5050.8  137.44  5702.2   143.1  6162.2   140.4  6242.2   143.3
  8582.2   142.9  8622.2     139  8692.2   143.9  8732.2   140.4  8772.2     143
  9372.2   143.9  9602.2   140.1  9862.2   142.6 10032.2   140.3 10141.2     144
#Mann= 5 ,-1 , 0
 -2097.4     .99       0  -154.1     .24       0  4491.7     .16       0
  4897.8     .06       0  5050.8     .24       0
#XS Ineff= 2 , 0
       0 2878.89   146.5               0
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
 4481.64 4904.94  131.99    8013   10079   142.9
Bank Sta=4897.8,5050.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,175264  ,190.2,414,98.1
BEGIN DESCRIPTION:
Cross Section Xs53.3
END DESCRIPTION:
XS GIS Cut Line= 6
      3014411.17      13914227.1      3020144.25     13909464.76
      3020200.56     13909477.08       3020290.1     13909496.55
      3020328.08     13909504.74      3021441.99     13908179.25
#Sta/Elev= 30
 -2578.4   149.4  -758.4   145.3  1571.6   139.2  1651.6   141.6  1731.6   138.9
  2201.6   136.7  2391.6   138.1  2681.6   134.6  3091.6   135.4  3141.6   138.7
  3471.6   137.7  3771.6   139.1  3851.6   142.3  3891.6   140.8  3991.6     138
  4341.6   136.1  4501.6   137.6  4937.3   133.8 4980.97  127.16 4983.67  123.43
 5000.67  122.69 5015.97  122.93    5034   132.4  5072.8   136.5  6002.8   143.3
  6052.8   141.3  6392.8   143.2  6442.8   141.2  6682.8   141.3  6794.2   146.1
#Mann= 7 ,-1 , 0
 -2578.4     .99       0  -758.4     .24       0  2391.6     .05       0
  3141.6     .24       0  3891.6      .2       0  4937.3   .0525       0
  5072.8     .24       0
#XS Ineff= 2 , 0
       0 3588.24   146.5 5622.84       0   146.5
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
 2391.61    3141   138.1
Bank Sta=4937.3,5072.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,174850. ,140,113,135.5
BEGIN DESCRIPTION:
K100-00-00-S27A_PIPELINE -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
        3014417.      13914227.8      3019982.71     13909817.08
      3020098.41     13909808.06       3021466.8     13908253.92
#Sta/Elev= 30
   -2160  149.34    -620  145.01    1070  143.18    2320  138.34    2440  140.31
    2590  137.06    3290  134.88    3720   138.7    4930  135.91 4945.13  131.25
 4978.37  127.63 4984.19  123.47 5000.67  122.75 5015.35  122.98 5027.54  128.81
 5040.05  130.61  5137.6  135.83  5277.6  131.93  5407.6  137.25  5617.6  136.65
  6167.6  141.81  6277.6  140.76  6317.6  142.87  6367.6  140.37  6407.6  142.49
  6757.6  142.88  6957.6   140.5  7047.6  141.52  7097.6  148.43  7128.3  148.55
#Mann= 4 ,-1 , 0
   -2160     .99       0    -620     .24       0    4930   .0525       0
  5137.6     .24       0
#XS Ineff= 2 , 0
        4379.255   146.55435.275           146.5
Permanent Ineff=
       F       F
Bank Sta=4930,5137.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,174737  ,25.1,25,61.5
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3014422.61      13914228.9       3019981.2     13909970.65
      3020109.63     13909869.99      3021481.83     13908351.59
#Sta/Elev= 30
 -2084.9     150  -125.7  145.41  1635.1   139.7  2145.2   141.5  2595.1   137.7
  2885.2   139.6  3185.2   137.3  3505.2   139.8  3705.1     137  4575.1   139.2
 4728.37  137.17 4926.67  139.44 4943.37  131.42 4968.77  129.15 4980.97  127.24
 4983.67  123.51 5000.67  122.77 5015.97  123.01 5028.67  129.39 5089.47  134.39
  5320.6   133.9  5520.5   138.6  5580.5   136.9  5840.6   137.8  6190.5   141.8
  6530.6   142.8  7000.6   140.5  7080.5   142.1  7100.5   147.5  7127.1   150.3
#Mann= 6 ,-1 , 0
 -2084.9     .99       0  -125.7     .24       0 4926.67     .09       0
 4968.77   .0525       0 5028.67     .09       0 5089.47     .24       0
#XS Ineff= 2 , 0
       0 4595.16   146.5 5384.08       0   146.5
Permanent Ineff=
       F       F
Bank Sta=4926.67,5089.47
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,174726.5,,,
BEGIN DESCRIPTION:
PL1_K100-00-00-PL27a
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,1,2.6,0, 16, 16, , , .95, 0, ,,,
    4946 4968.77 4980.97 4983.07 4983.57 4983.67 5000.67 5015.97 5016.37 5018.27
 5022.27 5028.67 5048.66 5048.77 5048.87    5059
  130.15  130.15   130.2  130.21  130.21  130.21  130.28  130.34  130.34  130.35
  130.37  130.39  130.53  130.53  130.54  130.54
  129.15  129.15   129.2  129.21  129.21  129.21  129.28  129.34  129.34  129.35
  129.37  129.39  129.53  129.53  129.54  129.54
    4946 4968.77 4980.97 4983.07 4983.57 4983.67 5000.67 5015.97 5016.37 5018.27
 5022.27 5028.67 5048.66 5048.77 5048.87    5059
  130.15  130.15   130.2  130.21  130.21  130.21  130.28  130.34  130.34  130.35
  130.37  130.39  130.53  130.53  130.54  130.54
  129.15  129.15   129.2  129.21  129.21  129.21  129.28  129.34  129.34  129.35
  129.37  129.39  129.53  129.53  129.54  129.54
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=150.3

Type RM Length L Ch R = 1 ,174712  ,64.1,67,143
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3014437.33     13914248.36        3019996.     13909990.03
      3020125.87     13909888.25      3021499.22     13908368.58
#Sta/Elev= 30
 -2084.9  149.49  -125.7   144.9  1635.1  139.19  2145.2  140.99  2595.1  137.19
  2885.2  139.09  3185.2  136.79  3505.2  139.29  3705.1  136.49  4575.1  138.69
 4728.37  136.66 4926.67  138.93 4943.37  130.91 4968.77  128.64 4980.97  126.73
 4983.67     123 5000.67  122.26 5015.97   122.5 5028.67  128.88 5089.47  133.88
  5320.6  133.39  5520.5  138.09  5580.5  136.39  5840.6  137.29  6190.5  141.29
  6530.6  142.29  7000.6  139.99  7080.5  141.59  7100.5  146.99  7127.1  149.79
#Mann= 6 ,-1 , 0
 -2084.9     .99       0  -125.7     .24       0 4926.67     .09       0
 4968.77   .0525       0 5028.67     .09       0 5089.47     .24       0
#XS Ineff= 2 , 0
       0 4647.06   146.5 5342.56       0   146.5
Permanent Ineff=
       F       F
Bank Sta=4926.67,5089.47
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,174645  ,31.6,31,32.8
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3014513.76      13914206.2      3019769.79     13910242.32
      3020293.91     13909839.68      3022610.37     13907842.59
#Sta/Elev= 30
 -2011.6  151.21 -1061.7  147.61  2718.3  144.21  2768.3  140.91  2888.9  141.55
  3548.3  143.11  3668.3  139.91  3968.3  140.11  4048.3  136.41  4114.6  140.13
  4568.3  142.51  4651.5  140.21  4925.4  144.38    4929  139.85  4941.1  134.26
  4985.9   125.8  5000.6  118.84  5056.8  133.59  5093.9  135.01  5121.4   145.1
  5336.2  143.19  5372.4  137.11  5412.4  135.71  5572.4  135.11  6282.4  142.61
  6875.5   143.9  7152.4  141.81  7232.4  144.51  8122.4  143.01    8291  145.31
#Mann= 8 ,-1 , 0
 -2011.6     .99       0  2718.3      .2       0  2888.9     .12       0
  4114.6     .24       0  4925.4   .0525       0  5121.4     .24       0
  6875.5     .12       0  7232.4     .99       0
#XS Ineff= 2 , 0
       0 4840.83   146.5 5167.82       0   146.5
Permanent Ineff=
       F       F
Bank Sta=4925.4,5121.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,174629  ,,,
BEGIN DESCRIPTION:
RAILROAD 130' US OF 290
Structure ID: K100-00-00-S27
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,12,2.6,0, 40, 40, , , .95, 0, ,,,
 -2011.7  -451.7   528.3  1728.3  4141.3  4876.3  4926.7  4926.8 4926.91    4927
  4928.4  4928.5    4929  4941.1  4962.9  4984.5  4984.7  4985.9  5000.6  5005.2
  5015.5  5016.2  5043.4  5056.8  5061.8  5093.9  5118.4  5118.5  5118.6 5119.89
    5120  5120.1    5121  5353.3  5483.3  7243.3  7683.3  8282.4  9043.3  9101.6
   150.7     148   146.3     144   144.3  145.04  145.16  145.16  145.16  145.16
  145.16  145.16  145.16  145.17  145.18  145.19  145.19  145.19   145.2   145.2
  145.19  145.19  145.18  145.17  145.17  145.19   145.2   145.2   145.2   145.2
   145.2   145.2  145.24   144.7   144.9   144.6   144.5  144.81   143.7   142.9
                                                          142.21  142.08  143.66
  143.66  143.66  143.66  143.67  143.68  143.69  143.69  143.69   143.7   143.7
  143.69  143.69  143.68  143.67  143.67  143.69   143.7   143.7   143.7   143.7
  143.11  143.22
 -2011.7  -451.7   528.3  1728.3  4141.3  4876.3  4926.7  4926.8 4926.91    4927
  4928.4  4928.5    4929  4941.1  4962.9  4984.5  4984.7  4985.9  5000.6  5005.2
  5015.5  5016.2  5043.4  5056.8  5061.8  5093.9  5118.4  5118.5  5118.6 5119.89
    5120  5120.1    5121  5353.3  5483.3  7243.3  7683.3  8282.4  9043.3  9101.6
   150.7     148   146.3     144   144.3  145.04  145.16  145.16  145.16  145.16
  145.16  145.16  145.16  145.17  145.18  145.19  145.19  145.19   145.2   145.2
  145.19  145.19  145.18  145.17  145.17  145.19   145.2   145.2   145.2   145.2
   145.2   145.2  145.24   144.7   144.9   144.6   144.5  144.81   143.7   142.9
                                                          142.21  142.08  143.66
  143.66  143.66  143.66  143.67  143.68  143.69  143.69  143.69   143.7   143.7
  143.69  143.69  143.68  143.67  143.67  143.69   143.7   143.7   143.7   143.7
  143.11  143.22
Pier Skew, UpSta & Num, DnSta & Num=  ,4941.9, 2 ,4941.9, 2 , 0 , 0 , 0 ,,
       1       1
  132.47  144.67
       1       1
  132.47  144.67
Pier Skew, UpSta & Num, DnSta & Num=  ,4956.9, 2 ,4956.9, 2 , 0 , 0 , 0 ,,
       1       1
  129.27  144.68
       1       1
  129.27  144.68
Pier Skew, UpSta & Num, DnSta & Num=  ,4971.8, 2 ,4971.8, 2 , 0 , 0 , 0 ,,
       1       1
  125.83  144.68
       1       1
  125.83  144.68
Pier Skew, UpSta & Num, DnSta & Num=  ,4986.8, 2 ,4986.8, 2 , 0 , 0 , 0 ,,
       1       1
  123.63  144.69
       1       1
  123.63  144.69
Pier Skew, UpSta & Num, DnSta & Num=  ,5002.1, 2 ,5002.1, 2 , 0 , 0 , 0 ,,
       1       1
  117.45   144.7
       1       1
  117.45   144.7
Pier Skew, UpSta & Num, DnSta & Num=  ,5016.9, 2 ,5016.9, 2 , 0 , 0 , 0 ,,
       1       1
  119.91  144.69
       1       1
  119.91  144.69
Pier Skew, UpSta & Num, DnSta & Num=  ,5031.4, 2 ,5031.4, 2 , 0 , 0 , 0 ,,
       1       1
  123.78  144.68
       1       1
  123.78  144.68
Pier Skew, UpSta & Num, DnSta & Num=  ,5046.9, 2 ,5046.9, 2 , 0 , 0 , 0 ,,
       1       1
  128.23  144.68
       1       1
  128.23  144.68
Pier Skew, UpSta & Num, DnSta & Num=  ,5060.1, 2 ,5060.1, 2 , 0 , 0 , 0 ,,
       1       1
  132.19  144.67
       1       1
  132.19  144.67
Pier Skew, UpSta & Num, DnSta & Num=  ,5075.1, 2 ,5075.1, 2 , 0 , 0 , 0 ,,
       1       1
  132.76  144.68
       1       1
  132.76  144.68
Pier Skew, UpSta & Num, DnSta & Num=  ,5090.2, 2 ,5090.2, 2 , 0 , 0 , 0 ,,
       1       1
  133.34  144.69
       1       1
  133.34  144.69
Pier Skew, UpSta & Num, DnSta & Num=  ,5105.1, 2 ,5105.1, 2 , 0 , 0 , 0 ,,
       1       1
  136.53  144.69
       1       1
  136.53  144.69
Abutment Skew #Up #Dn= , 2 , 2
  4926.8  4928.5
  143.66  140.19
  4926.8  4928.5
  143.66  140.19
Abutment Skew #Up #Dn= , 2 , 2
  5118.5 5120.09
  141.46   143.7
  5118.5 5120.09
  141.46   143.7
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=151.21

Type RM Length L Ch R = 1 ,174614  ,96.8,99,105.5
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3014533.46     13914229.83      3019789.56      13910265.9
      3020314.21     13909862.86      3022631.09      13907865.4
#Sta/Elev= 30
 -2011.6  151.12 -1061.7  147.52  2718.3  144.12  2768.3  140.82  2888.9  141.46
  3548.3  143.02  3668.3  139.82  3968.3  140.02  4048.3  136.32  4114.6  140.04
  4568.3  142.42  4651.5  140.12  4925.4  144.29    4929  139.76  4941.1  134.17
  4985.9  125.71  5000.6  118.75  5056.8   133.5  5093.9  134.92  5121.4  145.01
  5336.2   143.1  5372.4  137.02  5412.4  135.62  5572.4  135.02  6282.4  142.52
  6875.5  143.81  7152.4  141.72  7232.4  144.42  8122.4  142.92    8291  145.22
#Mann= 8 ,-1 , 0
 -2011.6     .99       0  2718.3      .2       0  2888.9     .12       0
  4114.6     .24       0  4925.4   .0525       0  5121.4     .24       0
  6875.5     .12       0  7232.4     .99       0
#XS Ineff= 2 , 0
       0 4852.94   145.4 5155.71       0   145.4
Permanent Ineff=
       F       F
Bank Sta=4925.4,5121.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,174515  ,66.2,69,68.4
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
ROB is ineffective therefore cross-section does not need to be extended.
END DESCRIPTION:
XS GIS Cut Line= 4
      3015621.19      13913500.6      3020022.76     13910203.03
      3020404.58     13909925.35      3023436.35      13907591.9
#Sta/Elev= 30
  -695.6  147.88   374.4  145.78   444.4  143.68  1414.4  142.18  2254.4  138.08
  2374.4  138.98  2864.4  135.68  2994.4  136.78  3494.4  135.28  3554.4  138.28
  3604.4  135.48  3704.4  135.58  3784.4  137.68  4474.4  136.98  4824.2  138.18
  4970.6  129.68  4994.2  122.63  4999.5  122.49  5009.4  123.52  5017.1  128.64
  5071.2  138.12  5164.2  141.18  5496.3  138.48  6016.3  139.98  6586.3  143.88
  6886.3  143.38  6916.3  144.98  7086.3  142.88  8646.3  142.38  9102.1  140.88
#Mann= 4 ,-1 , 0
  -695.6     .12       0  4824.2    .045       0  5164.2     .12       0
  6586.3     .99       0
#XS Ineff= 2 , 0
       0 4830.45   145.4 5162.63       0   145.4
Permanent Ineff=
       F       F
Bank Sta=4824.2,5164.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,174485  ,,,
BEGIN DESCRIPTION:
US 290 EB ACCESS RD/WEIR
Structure ID: K100-00-00-S26A
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,40,2.6,0, 153, 153, , , .95, 0, ,,,
  -695.6    -601  -365.6  -195.6    84.4    94.4   374.4     389     419   444.4
     469     509     809     869     989    1009    1069    1079    1109    1119
    1139    1159    1169  1184.4  1194.4    1269    1289  1314.4  1414.4  1458.5
    1469  1474.4    1499    1509    1519    1579    1669    1679  1684.4    1689
    1839    1909  2024.4    2079    2199  2244.4    2249  2254.4  2274.4    2289
  2334.4  2354.4  2364.4  2374.4    2379    2389    2459    2479    2549    2599
  2894.4  2944.4    2979  2984.4  2994.4    3279  3294.4  3724.4    3729  3784.4
    3889    3899    4209    4269    4339    4349    4359    4399  4474.4    4499
    4509    4549    4609    4649 4744.05 4744.16 4744.27  4784.4  4824.2 4828.71
  4828.8  4828.9  4854.2  4884.2  4894.2  4905.9 4918.86  4961.1  4970.6  4981.2
  4989.4  4993.9  4994.2  4999.5  5005.8  5006.3  5009.4  5017.1  5032.2  5064.2
  5071.2  5084.2  5104.2  5114.2 5148.21 5148.29  5148.4  5164.2  5214.2 5238.46
 5258.45 5258.56 5258.67 5258.76  5274.2  5276.3  5333.4  5496.3  5733.4  5813.4
  5863.4  6083.4  6176.3  6263.4  6353.4  6466.3  6563.4  6663.4  6766.3  6963.4
  7086.3  7186.3  7296.3  7496.3  7603.4  7853.4  8046.3  8346.3  8513.4  8646.3
  8803.4  9056.3  9102.1
   148.3  148.22  148.01  147.61  147.01  146.81  146.21     146   145.2  144.29
  144.08   144.7   143.8  143.65  143.52   143.5  143.43  143.42  143.39  143.38
  143.36  143.34  143.33  143.31  143.01  142.76  142.69  142.61  142.61  142.17
  142.06  142.01   141.9  141.86  141.82  141.56  141.18  141.13  141.11   141.1
  140.66  140.45  140.11     140     140  140.42   140.5  140.46  140.31   140.2
   140.3  140.35  140.37  140.39   140.4     140   140.2   140.6   140.3   140.2
  140.04  140.19   140.3  140.24  140.12   140.3  140.11  140.11   140.2  140.25
   140.2   140.5   140.4   140.3   140.5   140.2   140.8   140.5  140.88     141
   141.7     142   143.5   143.6  147.08  147.08  147.08  147.08  147.08  147.08
  147.08  147.08  147.08  147.08  147.08  147.08  147.08  147.07  147.06  147.06
  147.06  147.06  147.06  147.05  147.05  147.05  147.05  147.05  147.04  147.03
  147.03  147.03  147.02  147.02  147.01  147.01  147.01     147  146.99  146.98
  146.73  146.73  146.73  146.73  146.23  146.16   144.3     143   143.8     144
   144.7   145.5  145.79   146.4   147.4  147.66   147.6   147.6  147.85   147.1
  145.56  145.49  145.22   145.2   145.9   145.7  146.52   145.3   145.1  144.31
   144.2  143.64   141.3
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
          143.58  143.58  143.58  143.58  143.58  143.58  143.57  143.56  143.56
  143.56  143.56  143.56  143.55  143.55  143.55  143.55  143.55  143.54  143.53
  143.53  143.53  143.52  143.52  143.51
                                                                                
                                                                                
                                                                                
                        
  -695.6    -601  -365.6  -195.6    84.4    94.4   374.4     389     419   444.4
     469     509     809     869     989    1009    1069    1079    1109    1119
    1139    1159    1169  1184.4  1194.4    1269    1289  1314.4  1414.4  1458.5
    1469  1474.4    1499    1509    1519    1579    1669    1679  1684.4    1689
    1839    1909  2024.4    2079    2199  2244.4    2249  2254.4  2274.4    2289
  2334.4  2354.4  2364.4  2374.4    2379    2389    2459    2479    2549    2599
  2894.4  2944.4    2979  2984.4  2994.4    3279  3294.4  3724.4    3729  3784.4
    3889    3899    4209    4269    4339    4349    4359    4399  4474.4    4499
    4509    4549    4609    4649 4744.05 4744.16 4744.27  4784.4  4824.2 4828.71
  4828.8  4828.9  4854.2  4884.2  4894.2  4905.9 4918.86  4961.1  4970.6  4981.2
  4989.4  4993.9  4994.2  4999.5  5005.8  5006.3  5009.4  5017.1  5032.2  5064.2
  5071.2  5084.2  5104.2  5114.2 5148.21 5148.29  5148.4  5164.2  5214.2 5238.46
 5258.45 5258.56 5258.67 5258.76  5274.2  5276.3  5333.4  5496.3  5733.4  5813.4
  5863.4  6083.4  6176.3  6263.4  6353.4  6466.3  6563.4  6663.4  6766.3  6963.4
  7086.3  7186.3  7296.3  7496.3  7603.4  7853.4  8046.3  8346.3  8513.4  8646.3
  8803.4  9056.3  9102.1
   148.3  148.22  148.01  147.61  147.01  146.81  146.21     146   145.2  144.29
  144.08   144.7   143.8  143.65  143.52   143.5  143.43  143.42  143.39  143.38
  143.36  143.34  143.33  143.31  143.01  142.76  142.69  142.61  142.61  142.17
  142.06  142.01   141.9  141.86  141.82  141.56  141.18  141.13  141.11   141.1
  140.66  140.45  140.11     140     140  140.42   140.5  140.46  140.31   140.2
   140.3  140.35  140.37  140.39   140.4     140   140.2   140.6   140.3   140.2
  140.04  140.19   140.3  140.24  140.12   140.3  140.11  140.11   140.2  140.25
   140.2   140.5   140.4   140.3   140.5   140.2   140.8   140.5  140.88     141
   141.7     142   143.5   143.6  147.08  147.08  147.08  147.08  147.08  147.08
  147.08  147.08  147.08  147.08  147.08  147.08  147.08  147.07  147.06  147.06
  147.06  147.06  147.06  147.05  147.05  147.05  147.05  147.05  147.04  147.03
  147.03  147.03  147.02  147.02  147.01  147.01  147.01     147  146.99  146.98
  146.73  146.73  146.73  146.73  146.23  146.16   144.3     143   143.8     144
   144.7   145.5  145.79   146.4   147.4  147.66   147.6   147.6  147.85   147.1
  145.56  145.49  145.22   145.2   145.9   145.7  146.52   145.3   145.1  144.31
   144.2  143.64   141.3
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
          143.58  143.58  143.58  143.58  143.58  143.58  143.57  143.56  143.56
  143.56  143.56  143.56  143.55  143.55  143.55  143.55  143.55  143.54  143.53
  143.53  143.53  143.52  143.52  143.51
                                                                                
                                                                                
                                                                                
                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4908.5, 2 ,4908.5, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  140.74  144.58
     1.5     1.5
  140.74  144.58
Pier Skew, UpSta & Num, DnSta & Num=  ,4988.6, 2 ,4988.6, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  123.53  144.56
     1.5     1.5
  123.53  144.56
Pier Skew, UpSta & Num, DnSta & Num=  ,5068, 2 ,5068, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  138.63  144.53
     1.5     1.5
  138.63  144.53
BR Coef= 1 , 0 , 1 ,1.25, 0 ,,,.8,0,2,1,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 30
  -695.6   148.3   374.4   146.2   444.4   144.1  1414.4   142.6  2254.4   138.5
  2374.4   139.4  2864.4   136.1  2994.4   137.2  3494.4   135.7  3554.4   138.7
  3604.4   135.9  3784.4   138.1  4824.2   138.6  4894.2   135.4  4905.9  141.74
  4961.1  141.81  4970.6   130.1  4999.5  122.91  5009.4  123.94  5032.2  141.65
  5064.2  141.66  5071.2  138.54  5104.2     139  5214.2   142.1  5496.3   138.9
  6483.4  143.96  6886.3   143.8  6916.3   145.4  7086.3   143.3  9102.1   141.3
BR U #Mann= 4
  -695.6     .06  4824.2     .05  5104.2     .06  6483.4     .99
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=147.88

Type RM Length L Ch R = 1 ,174446  ,32.2,32,31.5
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
ROB is ineffective therefore cross-section does not need to be extended.
END DESCRIPTION:
XS GIS Cut Line= 4
      3015647.49     13913561.58      3020048.95     13910264.09
      3020430.87     13909986.33      3023462.86     13907652.72
#Sta/Elev= 30
  -695.6   148.3   374.4   146.2   444.4   144.1  1414.4   142.6  2254.4   138.5
  2374.4   139.4  2864.4   136.1  2994.4   137.2  3494.4   135.7  3554.4   138.7
  3604.4   135.9  3704.4     136  3784.4   138.1  4474.4   137.4  4824.2   138.6
  4970.6   130.1  4994.2  123.05  4999.5  122.91  5009.4  123.94  5017.1  129.06
  5071.2  138.54  5164.2   141.6  5496.3   138.9  6016.3   140.4  6586.3   144.3
  6886.3   143.8  6916.3   145.4  7086.3   143.3  8646.3   142.8  9102.1   141.3
#Mann= 4 ,-1 , 0
  -695.6     .12       0  4824.2    .045       0  5164.2     .12       0
  6586.3     .99       0
#XS Ineff= 2 , 0
       0 4809.69   144.6  5164.2       0   144.6
Permanent Ineff=
       F       F
Bank Sta=4824.2,5164.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,174414  ,226.3,233,227.6
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
     3015551.683    13913672.796      3019960.99     13910369.41
       3020606.6     13909890.41      3023446.15     13907687.72
#Sta/Elev= 30
  -819.7   147.2  -415.5   144.3  -285.5   147.2   -65.5   142.9    -5.5   144.7
   164.5   142.5   204.5   144.8   234.5   142.1   424.5   140.5   454.5     143
   584.5   143.9   754.5   141.9  2584.5   143.4  3054.5   141.4  4134.5   142.8
  4564.5   145.8  4592.8  142.77  4808.9  145.94    4971   130.1  4999.4  122.91
  5009.3  123.94  5017.1  129.06  5071.2  138.54    5132  140.57  5178.9  146.37
  5382.8  143.59  6641.8   141.6  7841.8   143.6  8691.8   140.1  9086.3   144.8
#Mann= 3 ,-1 , 0
  -819.7     .99       0  4808.9    .045       0  5178.9     .99       0
#XS Ineff= 2 , 0
       0  4798.9   145.7  5188.9       0   145.7
Permanent Ineff=
       T       T
Bank Sta=4808.9,5178.9
XS Rating Curve= 0
Exp/Cntr=.5,.3
