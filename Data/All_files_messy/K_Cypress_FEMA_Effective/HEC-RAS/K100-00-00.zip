HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,69040   ,660.8,1087,1167.7
BEGIN DESCRIPTION:
Cross Section XS24.7
END DESCRIPTION:
XS GIS Cut Line= 5
      3084397.91     13938752.47      3085285.65     13937949.61
      3085258.87     13937635.92      3085442.49     13937314.59
      3086758.92     13934915.08
#Sta/Elev= 30
  3617.4  108.97  4107.4   106.3  4777.4    91.5  4894.3   96.68 4901.64   93.26
 4993.35   69.18 5032.51   78.04 5075.82  100.97  5149.2  103.66  5219.2   94.06
  5289.2   91.18  5429.2   89.78  5529.3   95.01  5599.3   89.87  5659.3   98.41
  5809.3  101.07  6569.3   98.76  6629.3  102.01  6689.3   97.88  6859.3   98.29
  6909.3   90.31  6949.3    99.5  7049.3  102.55  7329.3  104.18  7719.3  100.73
  7849.3  103.36  7889.3  108.59  8029.3  106.37  8079.3  112.36  8236.2  120.36
#Mann= 3 ,-1 , 0
  3617.4      .1       0 4901.64   .0385       0 5075.82      .1       0
#XS Ineff= 2 , 0
                         7324.22           104.2
Permanent Ineff=
       F       F
Bank Sta=4901.64,5075.82
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,67953   ,112.9,191,163.2
BEGIN DESCRIPTION:
Cross Section XS24.5
END DESCRIPTION:
XS GIS Cut Line= 6
      3084425.55      13938738.3      3085810.58     13938042.78
      3086179.13     13937820.64      3086267.53      13937768.4
      3086329.08     13937732.41      3088112.03     13935538.88
#Sta/Elev= 30
  2964.9   108.7  3054.9   106.4  3404.9   106.5  3474.9   103.3  4094.9    95.9
  4874.8    92.5  4924.8      86  4955.1    75.9 4973.62   73.44 4979.22   69.63
 5004.22   66.44 5021.92   70.15  5025.1    75.5  5087.8   104.1  5097.8     105
  5129.1    98.4  5459.1    98.2  5479.1    99.4  5499.1   105.5  5549.1    98.9
  6109.1   100.6  6599.1      96  6639.1      98  7119.1    98.6  7189.1    95.7
  7219.1      99  7479.1     101  7669.1   106.5  7779.1   105.8  7945.8   110.8
#Mann= 3 , 0 , 0
  2964.9     .14       0  4874.8   .0385       0  5087.8     .99       0
#Block Obstruct= 1 ,-1
  5097.8    5499     105
Bank Sta=4874.8,5087.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,67762.  ,109.9,107,68
BEGIN DESCRIPTION:
K100-00-00-S9A_PIPELINE US - XS4
END DESCRIPTION:
XS GIS Cut Line= 5
      3084513.82      13938744.6      3085515.84     13938237.34
      3086124.96     13938046.47      3086379.51      13937922.9
      3088201.16     13935691.51
#Sta/Elev= 30
  3082.4   108.4  3152.4  105.85  3662.4  104.03  3812.4  100.39  4162.4   95.56
  4545.5      97  4695.5   94.56 4920.47   85.97 4954.57   78.11 4978.37   68.94
 5000.85   65.94 5016.04   69.27 5020.29   73.42  5043.8   79.84  5073.8   94.84
  5103.8  104.29  5146.8   98.58  5426.8   97.42  5656.8   99.56  5696.8  106.96
  5736.8  100.58  5866.8   98.64  5946.8  101.16  6356.8  100.09  6716.8   96.01
  7186.8   99.56  7296.8   95.21  7356.8  100.56  7586.8  101.87  8007.3  110.44
#Mann= 4 ,-1 , 0
  3082.4      .1       0  3812.4     .14       0 4920.47   .0385       0
  5103.8     .99       0
#Block Obstruct= 1 ,-1
 5101.75 5697.97  104.08
Bank Sta=4920.47,5103.8
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,67655   ,24.9,22,20.7
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
      3084534.63      13938787.9      3085531.63     13938295.54
      3086152.03     13938143.28      3086359.91     13938042.31
      3088228.23     13935788.32
#Sta/Elev= 30
2893.533  108.163543.473  103.623794.164   97.924297.404    95.94325.258   91.08
 4381.06   96.814535.189   89.584537.343    89.34570.583   84.994588.688    78.7
4602.987   78.984623.135   68.854646.348   65.664662.781   69.374711.434   95.66
 4726.94   95.414780.124  105.754808.071   98.084891.635   96.56  5346.5  100.43
5374.447     1065402.302   101.25541.575   98.225634.423  101.016302.933   95.65
 6795.03   99.51 6850.74   95.936924.926  101.327129.192  102.237452.027  110.13
#Mann= 5 ,-1 , 0
2893.533      .2       03794.164     .08       04535.189    .065       0
4537.343   .0385       04711.434     .99       0
#XS Ineff= 2 , 0
       04406.343   96.244720.719       0   95.39
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
4779.3995374.159  105.69
Bank Sta=4537.343,4711.434
XS Rating Curve= 0
Skew Angle= 21.8
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,67644   ,,,
BEGIN DESCRIPTION:
PL1_K100-00-00-S9A
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,2,2.6,21.8, 60, 60, , , .95, 0, ,,,
2893.5333051.3763088.6083144.2243543.566 3589.993926.009 4232.414297.4974306.781
4316.0664325.2584353.113 4381.06  4418.24473.9094510.9564519.2194528.8014528.903
4528.9864703.3474704.8234711.434 4726.944761.5544780.2164808.0714826.6414891.542
4956.536  5346.55365.0695374.4475383.7325402.3025504.4355541.5755569.3365634.423
5745.7496052.1496302.9336330.6956507.1076572.1946618.525 6795.036850.6466878.501
6924.9267082.7687129.1927194.1877268.465 7296.327342.8377398.5467451.9347452.027
  108.13  105.47  106.51  105.34  103.59  101.03   95.86   96.63   95.87   95.14
   91.29   91.05   96.39   96.78   95.49   91.66   92.36   91.66   93.19   93.19
   93.19   92.15    91.8   95.64   95.39  104.62  105.73   98.05   98.83   96.53
   98.21   100.4   104.9  105.98  105.11  101.17   100.4   98.19  100.01  100.98
   98.66   95.57   95.62   97.17   98.96   96.75   98.37   99.48    95.9   99.45
  101.29  103.53   102.2  105.84  106.74  108.27  108.59   107.3   110.1   110.1
  108.13  105.47  106.51  105.34  103.58  101.03   95.86   96.63   95.86    95.1
   91.29   91.05   96.38   96.78   95.48   91.66   92.36   91.65   90.39   90.38
   91.69   90.93   91.79   95.63   95.38   104.6  105.72   98.05   98.83   96.53
   98.21   100.4  104.87  105.97   105.1  101.17  100.39   98.19     100  100.98
   98.66   95.57   95.62   97.16   98.96   96.75   98.37   99.48    95.9   99.44
  101.29  103.53   102.2  105.84  106.74  108.26  108.59  107.29   110.1   110.1
2893.5333051.3763088.6083144.2243543.4733589.8973926.009 4093.23 4232.414297.404
4306.7814316.0664325.2584353.206 4381.064418.1074473.9094510.9564519.2194528.801
4528.9034528.9864703.3474704.8234711.434 4726.944761.5544780.1244808.0714826.641
4891.5424956.536  5346.55365.0695374.4475383.7325402.3025504.4355541.5755569.429
5634.4235745.7496052.1496302.9336330.7886507.1076572.1946618.525 6795.03 6850.74
6878.5016924.9267082.7687129.1927194.1877342.7447398.5467426.3087451.9347452.027
  108.14  105.48  106.52  105.35   103.6  101.04   95.87    95.6   96.64   95.88
   95.14    91.3   91.06    96.4   96.79    95.5   91.67   92.37   91.66   93.19
   93.19   93.19   92.15    91.8   95.64   95.39  104.62  105.73   98.06   98.84
   96.54   98.22  100.41   104.9  105.98  105.11  101.18   100.4    98.2  100.02
  100.99   98.67   95.58   95.63   97.18   98.97   96.76   98.38   99.49   95.91
   99.45   101.3  103.54  102.21  105.85   108.6   107.3  109.46  110.11  110.11
  108.14  105.48  106.52  105.35   103.6  101.04   95.87    95.6   96.64   95.88
   95.11    91.3   91.06    96.4   96.79    95.5   91.67   92.37   91.66    90.4
   90.39    91.7   90.94    91.8   95.64   95.39  104.61  105.73   98.06   98.84
   96.54   98.22  100.41  104.88  105.98  105.11  101.18   100.4    98.2  100.02
  100.99   98.67   95.58   95.63   97.18   98.97   96.76   98.38   99.49   95.91
   99.45   101.3  103.54  102.21  105.85   108.6   107.3  109.46  110.11  110.11
Pier Skew, UpSta & Num, DnSta & Num=  ,4550.602, 2 ,4550.602, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   85.23   92.56
     1.5     1.5
   85.24   92.57
Pier Skew, UpSta & Num, DnSta & Num=  ,4596.933, 2 ,4596.933, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   77.49   92.28
     1.5     1.5
    77.5   92.29
Pier Skew, UpSta & Num, DnSta & Num=  ,4643.915, 2 ,4643.915, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   64.89      92
     1.5     1.5
    64.9   92.01
Pier Skew, UpSta & Num, DnSta & Num=  ,4687.832, 2 ,4687.832, 2 , 0 , 0 , 0 ,,
       1       1
   81.34   91.74
       1       1
   81.35   91.75
Pier Skew, UpSta & Num, DnSta & Num=  ,4694.889, 2 ,4694.889, 2 , 0 , 0 , 0 ,,
       1       1
   84.81   91.71
       1       1
   84.82   91.72
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=110.13

Type RM Length L Ch R = 1 ,67633   ,38.7,100,144.3
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
       3084545.1     13938804.15      3085539.85      13938312.9
      3086160.17     13938160.66      3086374.73     13938056.45
      3088246.23     13935798.62
#Sta/Elev= 30
2893.533  108.353543.473  103.813794.164   98.114297.404   96.094325.258   91.27
 4381.06      974535.189   89.774537.343   89.494570.583   85.184588.688   78.89
4602.987   79.174623.135   69.044646.348   65.854662.781   69.564711.434   95.85
 4726.94    95.64780.124  105.944808.071   98.274891.635   96.75  5346.5  100.62
5374.447  106.195402.302  101.395541.575   98.415634.423   101.26302.933   95.84
 6795.03    99.7 6850.74   96.126924.926  101.517129.192  102.427452.027  110.32
#Mann= 5 ,-1 , 0
2893.533      .2       03794.164     .08       04535.189    .065       0
4537.343   .0385       04711.434     .99       0
#XS Ineff= 2 , 0
       04418.005   96.314717.627       0   95.39
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
4778.9915374.503  105.91
Bank Sta=4537.343,4711.434
XS Rating Curve= 0
Skew Angle= 21.8
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,67533   ,1803.8,1776,1420.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X25
END DESCRIPTION:
XS GIS Cut Line= 4
      3084692.92     13938976.59      3086034.24     13938210.84
      3086429.41     13938203.36      3088214.31     13936080.53
#Sta/Elev= 30
  3229.7   107.1  3519.7   103.7  3910.9  104.42  4319.7    99.7  4489.7    94.7
  4739.7    97.1  4804.2    95.2  4864.2    88.6  4904.2    90.2  4933.3   82.17
  4959.8   80.74  4979.5   71.27  5006.1   67.73  5028.3   73.47  5076.8   93.04
  5102.9   93.17    5156  104.73  5179.4   105.6  5209.4    97.5  5679.4    98.2
  5919.4   101.4  5949.4   105.8  5999.4   100.1  6129.4    98.1  6929.4    96.5
  7459.4    99.9  7499.4    97.6  7559.4   102.4  7809.4   103.9  7942.9   109.4
#Mann= 5 ,-1 , 0
  3229.7     .99       0  3910.9     .14       0  4904.2   .0385       0
  5076.8    .055       0  5179.4     .99       0
#Block Obstruct= 1 ,-1
 5170.61 5949.31   105.6
Bank Sta=4904.2,5076.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,65757   ,1598,1857,1369.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X24A
END DESCRIPTION:
XS GIS Cut Line= 4
       3086212.9      13940828.7      3086783.58     13939815.95
      3087162.87     13939609.42      3089358.73     13936793.98
#Sta/Elev= 30
  3634.6   106.6  4484.6    99.5  4664.6    93.7  4734.6    95.9  4797.1    90.1
    4965   85.85  4966.3   73.93  4978.1   65.55  5018.7   65.73  5025.6   69.36
  5077.3    83.4  5087.6   91.51  5137.1    92.6  5167.1    88.3  5258.9    94.7
  5878.9    98.9  6948.9    97.1  7078.9    98.9  7148.9    95.5  7318.9    96.1
  7368.9    93.1  7408.9    95.4  7678.9      99  7828.9    96.6  8318.9   105.9
  8438.9   104.8  8488.9   108.2  8728.9   109.3  8758.9   112.1  8799.5   112.3
#Mann= 4 ,-1 , 0
  3634.6     .14       0    4965   .0385       0  5087.6     .14       0
  5878.9     .99       0
Bank Sta=4965,5087.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,63900   ,1290.1,1198,1073.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X24
END DESCRIPTION:
XS GIS Cut Line= 4
      3087654.95     13941476.83      3087952.52     13940875.85
      3088236.06     13940581.17      3090620.65      13937054.8
#Sta/Elev= 30
  4245.4   107.7  4405.4   101.6  4555.4   102.6  4637.6   93.79  4785.4    84.8
  4905.4    94.1  4933.2   91.68  4973.4   68.79    5002   64.08  5051.4   75.21
  5070.5   90.71    5405    96.1    5695    91.8    5785    96.1    5865    91.9
    5915    96.6  6079.8    96.9    6505    94.5    7065    98.2    7635    94.3
    7685    89.1    7735    94.9    8155    93.5    8345     103    8465    98.6
    8515   104.1    8585     105    8795   101.7    8835   104.8  9581.9   111.4
#Mann= 5 ,-1 , 0
  4245.4     .99       0  4637.6     .14       0  4933.2   .0385       0
  5070.5     .14       0  6079.8     .99       0
Bank Sta=4933.2,5070.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,62702   ,1261.3,1552,1565.8
BEGIN DESCRIPTION:
Cross Section XS23.5
END DESCRIPTION:
XS GIS Cut Line= 6
      3088787.17      13942459.3      3089152.32     13941363.28
      3089157.36     13941209.89      3089157.36      13941067.9
       3089154.6     13941000.05      3091231.31     13937482.42
#Sta/Elev= 30
  3602.9   112.2  4432.9   103.6  4722.9     103  4858.2    94.7  4898.2    95.1
  4921.7    91.5  4951.7    80.5  4973.4   69.15    5002   64.44  5026.7   69.14
  5031.7    74.7  5041.7    77.1  5053.7    84.2  5093.7      91  5151.6    94.1
  5291.6    95.8  5581.6    89.7  5821.6    93.3  5931.6    89.7  6271.6    88.9
  6901.6    93.4  7081.6    99.7  8041.6   100.5  8201.6   101.8  8281.6   105.7
  8381.6   102.8  8581.6   107.4  8961.6   110.9  9121.6   109.6  9206.5   112.3
#Mann= 5 ,-1 , 0
  3602.9     .99       0  4432.9     .14       0  4898.2   .0385       0
  5151.6     .14       0  5821.6     .99       0
Bank Sta=4898.2,5151.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,61150   ,1083.7,868,575.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X23
END DESCRIPTION:
XS GIS Cut Line= 4
      3089639.74     13942549.59      3090281.16     13941666.92
      3091065.04     13941034.34      3092434.88     13938313.48
#Sta/Elev= 30
  3458.5   106.8  3548.5   102.7  3778.5   103.4  3878.5   100.1  3918.5   102.5
  4008.5   103.4  4360.5   98.53  4518.5    91.5  4759.6    93.3  4869.6    88.2
  4908.6   89.98  4947.7   88.13  4988.8   70.69  4990.7   67.45  4999.4    64.9
  5030.1   69.69  5043.6   78.16  5054.5   78.64  5071.8   91.99  5123.7   92.72
  5556.9    96.2  6326.9    95.9  6706.9    99.2  6796.9    97.8  6846.9   101.4
  7036.9   103.9  7116.9   100.6  7286.9   103.6  7756.9   102.6  8603.1   110.5
#Mann= 5 ,-1 , 0
  3458.5     .99       0  4360.5     .14       0  4947.7   .0385       0
  5123.7     .12       0  6846.9     .99       0
Bank Sta=4947.7,5123.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,60282   ,1127.6,1302,833.5
BEGIN DESCRIPTION:
Cross Section XS22.5
END DESCRIPTION:
XS GIS Cut Line= 6
      3090721.01      13943256.4      3091291.02     13942096.28
      3091279.41     13941966.54       3091269.3     13941862.09
       3091257.9     13941507.76      3092587.55     13938388.51
#Sta/Elev= 30
  3534.2   108.5  3764.2   106.7  3804.2   104.4 4120.84   99.32  4354.299.20314
 4600.08   99.08  4624.2    95.5  4896.8    91.4  4906.8    91.1  4941.6   82.82
  4981.3   68.29  5009.8   60.82  5040.7   68.08    5092    74.4    5112    81.3
    5142    83.6    5172    82.6    5272      92    5342      93  5466.5    89.8
  5586.5      90  5996.5      96  6316.5    93.9  6346.5    95.6  6526.5    94.7
  7176.5    99.5  7366.5   101.4  7926.5   100.9  8536.5   105.5  8807.3   110.1
#Mann= 5 ,-1 , 0
  3534.2     .99       0  4354.2     .14       0  4896.8    .055       0
    5272     .12       0  7176.5     .99       0
Bank Sta=4896.8,5272
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,58980   ,1594.9,1592,1206.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X22
END DESCRIPTION:
XS GIS Cut Line= 4
      3091825.68     13943374.87      3092491.55     13941627.34
      3092007.54     13940949.22      3092649.57     13938534.52
#Sta/Elev= 30
    2682   106.2    3212     103 3442.49   98.67 3911.07   98.74  3946.9   88.95
 3999.28   89.08 4051.65   80.04 4062.67      75 4354.84   75.07 4440.29   91.36
  4572.1    90.7  4622.1    87.6  4802.1    91.4  4852.1    95.6  4902.1    93.5
  4912.1    89.3  4915.4   82.16  4941.6   76.69  5009.8   54.69  5040.7   61.95
  5046.7   67.16    5092   86.55  5262.1    95.3  5965.2    93.7  6445.2   100.2
  6515.2    96.8  6825.2    96.7  6895.2    99.7  7705.2   104.5  7883.8   108.7
#Mann= 6 ,-1 , 0
    2682     .14       0 4051.65    .035       0 4440.29     .14       0
  4912.1    .055       0    5092     .14       0  6445.2     .99       0
#XS Ineff= 1 ,-1
 3793.92 4442.57      91
Permanent Ineff=
       T
#Block Obstruct= 1 ,-1
 3956.08 4472.97      82
Bank Sta=4912.1,5092
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,57388   ,772.4,1314,1119.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X21
END DESCRIPTION:
XS GIS Cut Line= 4
      3094310.22     13945522.14      3094175.69     13942268.22
      3093321.17     13941176.66       3093282.2     13939073.22
#Sta/Elev= 30
   912.5   108.3  3080.9    99.3  3172.2      95  3311.1      82  3377.9      89
  3442.5   100.5  4012.5    96.5  4239.2    88.8  4409.2    88.3  4469.2    83.9
  4719.2    87.2  4869.2    95.2  4929.7   93.44 4947.46   79.67 4971.48   66.96
    5008   65.22 5054.22   74.08  5070.1   84.75  5109.1    92.9  5159.2     100
  5309.2    92.2  5995.5    96.8  6410.1   89.35  6565.5   101.1  6685.5    97.9
  7125.5   107.4  7165.5   104.6  7355.5   108.4  7575.5   106.2  7659.3   108.4
#Mann= 5 ,-1 , 0
   912.5     .99       0  4012.5     .14       0  4929.7    .055       0
  5109.1     .14       0  6410.1     .99       0
#XS Ineff= 3 ,-1
                            4000    4900    95.5    5185    6600      98
Permanent Ineff=
       F       T       T
#Block Obstruct= 3 ,-1
                                                  3080.9  3442.5      99
Bank Sta=4929.7,5109.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,56074   ,500,675,630
BEGIN DESCRIPTION:
New Section
END DESCRIPTION:
XS GIS Cut Line= 6
      3094783.67     13943258.15      3094764.14     13941960.64
     3094730.162     13941695.18     3094483.986      13940720.1
     3094457.029     13940613.33     3094278.829      13939378.2
#Sta/Elev= 30
       0     100  318.27     100  447.54   98.24  624.73   99.76     786   98.29
 1702.56   99.06  1788.4   89.86  1860.7   74.27  2070.4   73.66  2141.8   88.42
 2194.13      90 2315.42      90 2362.87    87.4    2471      88 2497.67    85.2
 2524.81   69.03 2535.83   67.55 2569.92   57.49 2618.71   68.53    2645   72.88
 2653.38   75.92  2660.8   80.24 2687.34   82.53  2695.2      88 2700.09   92.73
  2813.9      94 2873.97    92.2 3135.11      92 3292.33      96    3929     100
#Mann= 7 ,-1 , 0
       0     .99       0     786     .14       0  1788.4    .035       0
  2141.8     .14       0    2471    .055       0 2700.09     .12       0
 3292.33     .99       0
#XS Ineff= 1 ,-1
  1788.4  2141.8      90
Permanent Ineff=
       T
#Block Obstruct= 1 ,-1
  1788.4  2141.8    79.2
Bank Sta=2471,2695.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,55399   ,1246.6,1830,1474.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-XS20C
END DESCRIPTION:
XS GIS Cut Line= 4
      3094969.03     13945261.37       3095086.6     13940867.41
      3094973.47     13940427.47       3094942.9     13938376.78
#Sta/Elev= 30
   366.9   101.8   636.9     104  1326.9   100.1  1756.9   102.1  1876.9    98.5
  2116.9     101  2666.9    97.4  3006.9    98.9  3236.9    96.1  3244.3      99
  3574.8   99.18  3674.4   90.63 3743.24   72.47  4129.1    72.8  4200.9   89.39
  4286.9    86.3  4596.9    92.6  4912.3   87.27  4949.9   66.76  4952.9   71.33
  4997.6   53.37    5050    66.8  5079.5   68.91  5099.6   77.14    5127   78.31
  5141.3   92.64  5356.7    87.9  5926.7    96.5  6276.7    96.5  7267.6   108.9
#Mann= 7 ,-1 , 0
   366.9     .99       0  3006.9     .14       0  3574.8    .035       0
  4200.9     .14       0  4912.3    .055       0  5141.3     .12       0
  5926.7     .99       0
#XS Ineff= 1 ,-1
 3590.27 4232.43      90
Permanent Ineff=
       T
#Block Obstruct= 1 ,-1
  3674.4  4200.9    79.2
Bank Sta=4912.3,5141.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,53569   ,661.9,1108,778.6
BEGIN DESCRIPTION:
Cross Section XS20.4
END DESCRIPTION:
XS GIS Cut Line= 5
      3095160.12      13945075.7      3096454.88     13941319.84
      3096448.48     13940769.72      3096444.94     13940627.85
      3096425.86     13938693.79
#Sta/Elev= 30
   393.2   104.7   763.2   103.4   813.2    99.8  1003.2   102.1  1793.2    97.7
  1983.2   100.9  2653.2    96.9  2963.2    95.4  3543.2    88.5  3723.2    89.8
  3793.2    84.3  3983.2    90.1  4223.2    90.5  4303.2    86.6    4496      89
    4586    85.9    4746    90.5    4896    88.1  4942.3   83.57  4949.7   73.86
  4963.7   63.74  4985.9    57.8  5036.4   63.77  5068.1    78.5  5118.1      88
  5188.1      92  5778.1    91.9  6138.1    99.9  6548.1   109.4  6992.2   112.8
#Mann= 7 ,-1 , 0
   393.2     .99       0  2653.2      .1       0  2963.2     .14       0
    4896   .0385       0  5118.1     .12       0  6138.1     .06       0
  6548.1      .1       0
Bank Sta=4896,5118.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,52461   ,535.1,1054,1009.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X20B
END DESCRIPTION:
XS GIS Cut Line= 4
       3095424.8     13944970.06      3097174.48      13941509.1
      3097169.93     13941055.97      3097133.14     13938532.56
#Sta/Elev= 30
   941.2   104.3  1081.2   100.5  1631.2   101.9  2171.2    98.3  2351.2   101.2
  2521.2    96.4  2671.2   100.5  3011.2      94  3105.1   95.53  3581.2    95.7
  4191.2    89.8  4361.2    93.2  4691.2    84.3  4899.3    89.7  4929.3    85.8
  4933.5   89.13  4942.3   86.25  4949.7   76.54  4963.7   66.42  4985.9   60.48
  5036.4   66.45  5104.3   84.59  5160.2   88.32  5292.4    86.5  5442.4    90.6
  5892.4    86.1    6625   98.43  6672.4   101.7  7242.4   110.5  7796.1     110
#Mann= 5 ,-1 , 0
   941.2     .99       0  3105.1     .14       0  4933.5   .0385       0
  5160.2     .12       0    6625     .06       0
Bank Sta=4933.5,5160.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,51407   ,864.3,246,192.6
BEGIN DESCRIPTION:
Cross Section XS20.3
END DESCRIPTION:
XS GIS Cut Line= 6
      3096271.35       13944198.      3097413.85     13941924.55
      3097887.95     13941147.17      3097931.59     13941081.71
      3098008.17     13940966.91      3098039.82     13939507.31
#Sta/Elev= 30
  1493.2    99.2  1543.2   101.4  1723.2   100.9  1763.2    98.6  1993.2    99.6
  2713.2    92.8  2983.2      94  3433.2    90.8  3843.2    92.4  3903.2    90.3
  4177.6    88.3  4317.6    89.7  4377.6    87.7  4567.6    91.4  4917.6    85.4
  4948.1    78.1  4963.7   69.84  4985.9    63.9  5011.2   64.78  5036.4   69.87
  5066.8    82.1  5096.8    86.5  5464.8    92.5  5754.8    99.9  5794.8    98.6
  5834.8   101.7  5914.8   103.4  6224.8   108.4  6424.8   108.4  6624.8   110.3
#Mann= 5 ,-1 , 0
  1493.2     .99       0  2713.2     .14       0  4917.6   .0385       0
  5096.8     .12       0  6424.8     .99       0
#XS Ineff= 2 , 0
         3835.94   93.98  5154.3           97.89
Permanent Ineff=
       F       F
Bank Sta=4917.6,5096.8
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,51161   ,333.9,354,357.7
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
      3097086.92     13944146.61      3097727.35     13943715.55
      3098011.29     13941921.79      3098070.85     13940824.69
      3098110.71       13939532.
#Sta/Elev= 30
1389.442  100.76 1760.62   98.761899.812   94.262047.432   93.082117.879   95.06
2635.981   89.162922.098   91.063076.755   88.363185.015   90.763370.604   87.46
3616.123   88.973666.309   86.513727.322   88.673756.707   84.96 3821.74   82.45
3847.104   66.863868.833   64.363885.304   66.593887.083   69.45 3933.48   83.26
3950.338   82.983969.051    87.83975.469   87.263997.817   86.214238.464   89.52
4263.596   93.064340.925   92.564882.226  107.865178.086  109.89 5240.49  110.26
#Mann= 5 ,-1 , 0
1389.442     .99       02047.432     .14       03727.322   .0385       0
3975.469     .14       05178.086     .99       0
#XS Ineff= 2 , 0
       0 3719.73   95.19 3988.28       0   97.75
Permanent Ineff=
       F       F
Bank Sta=3727.322,3975.469
XS Rating Curve= 0
Skew Angle= 39.35
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,50993.5 ,,,
BEGIN DESCRIPTION:
IH45 & ACCESS ROADS - Structure ID: K100-00-00-S8
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,315,2.6,39.35, 123, 123, , , .95, 0, ,,,
1389.4421497.7031714.2231729.689 1760.621783.8191853.4151899.8121969.4081984.874
 1986.422047.4322063.749 2094.682117.8792210.6732217.5562248.4872288.0022303.468
2326.667 2388.532465.8582477.612 2550.922558.6532635.9812759.7072782.9062806.104
2922.0982983.9613007.1593076.7553107.6873130.8853146.3513161.8173185.0153209.451
3239.1453270.077 3277.813293.2753370.6043387.3073390.7873418.2393425.971 3449.17
3534.5413536.629    35783578.3863616.1233618.211 3657.883666.3093691.6733697.241
3723.6873723.8423723.919 3724.463727.3223755.7783756.7073788.3343788.9523807.202
3820.271 3821.743846.7173847.1043848.3413852.7493853.5223868.8333884.2993885.304
3885.6913887.0833917.782 3933.483949.7963950.3383969.0513975.4693982.1973982.267
3982.3523982.4293997.8174006.3164006.4014279.062 4284.324286.7954292.0534294.528
4317.7274325.4594340.9254348.658 4487.854489.7834511.0484541.9794557.4454570.437
4611.5764634.774 4650.244665.7064696.6374882.2264951.8224959.5554982.7535021.417
5178.0865178.163 5240.49
   100.8    99.9      99    98.2    98.8    98.4    95.3    94.3    94.1    94.4
    94.3    95.9   95.87   95.82   95.78   95.61    95.6    95.3   95.39   95.42
   95.47   95.61   95.78    95.8   95.96   95.98   96.15   96.42   96.47   96.52
   96.77   96.91   96.96   97.11   97.18   97.23   97.26    97.3   97.35    97.4
   97.37   97.33   97.32   97.31   97.22    97.2   97.16    96.8      97    96.9
   96.79   96.83   97.74   97.75   98.49   98.53   99.31   99.43    99.8   99.85
  100.08  100.08  100.08  100.08   100.1  100.23  100.23  100.37  100.37  100.39
   100.4   100.4  100.34  100.34  100.34  100.33  100.33  100.24  100.15  100.15
  100.14  100.14   99.96   99.87   99.78   99.78   99.64    99.6   99.55   99.55
   99.55   99.55   99.32   99.19   99.19   99.44   100.3  100.17    99.9   99.91
  100.01  100.04  100.11  100.14  100.74  100.75  100.84  100.98  101.04   101.1
  101.32  101.71  101.71   101.6  103.31  107.91  108.41  108.01  109.31  109.01
  109.94  109.93   110.3
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
           95.37   95.37   95.37   95.39   95.52   95.52   95.66   95.66   95.68
   95.69   95.69   95.63   95.63   95.63   95.62   95.62   95.53   95.44   95.44
   95.43   95.43   95.25   95.16   95.07   95.07   94.93   94.89   94.84   94.84
                                                                                
                                                                                
                                                                                
                        
1389.4421497.7031714.2231729.689 1760.621783.8191853.4151899.8121969.4081984.874
 1986.422047.4322063.749 2094.682117.8792210.6732217.5562248.4872288.0022303.468
2326.667 2388.532465.8582477.612 2550.922558.6532635.9812759.7072782.9062806.104
2922.0982983.9613007.1593076.7553107.6873130.8853146.3513161.8173185.0153209.451
3239.1453270.077 3277.813293.2753370.6043387.3073390.7873418.2393425.971 3449.17
3534.5413536.629    35783578.3863616.1233618.211 3657.883666.3093691.6733697.241
3723.6873723.8423723.919 3724.463727.3223755.7783756.7073788.3343788.9523807.202
3820.271 3821.743846.7173847.1043848.3413852.7493853.5223868.8333884.2993885.304
3885.6913887.0833917.782 3933.483949.7963950.3383969.0513975.4693982.1973982.267
3982.3523982.4293997.8174006.3164006.4014279.062 4284.324286.7954292.0534294.528
4317.7274325.4594340.9254348.658 4487.854489.7834511.0484541.9794557.4454570.437
4611.5764634.774 4650.244665.7064696.6374882.2264951.8224959.5554982.7535021.417
5178.0865178.163 5240.49
   100.8    99.9      99    98.2    98.8    98.4    95.3    94.3    94.1    94.4
    94.3    95.9   95.87   95.82   95.78   95.61    95.6    95.3   95.39   95.42
   95.47   95.61   95.78    95.8   95.96   95.98   96.15   96.42   96.47   96.52
   96.77   96.91   96.96   97.11   97.18   97.23   97.26    97.3   97.35    97.4
   97.37   97.33   97.32   97.31   97.22    97.2   97.16    96.8      97    96.9
   96.79   96.83   97.74   97.75   98.49   98.53   99.31   99.43    99.8   99.85
  100.08  100.08  100.08  100.08   100.1  100.23  100.23  100.37  100.37  100.39
   100.4   100.4  100.34  100.34  100.34  100.33  100.33  100.24  100.15  100.15
  100.14  100.14   99.96   99.87   99.78   99.78   99.64    99.6   99.55   99.55
   99.55   99.55   99.32   99.19   99.19   99.44   100.3  100.17    99.9   99.91
  100.01  100.04  100.11  100.14  100.74  100.75  100.84  100.98  101.04   101.1
  101.32  101.71  101.71   101.6  103.31  107.91  108.41  108.01  109.31  109.01
  109.94  109.93   110.3
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
           95.37   95.37   95.37   95.39   95.52   95.52   95.66   95.66   95.68
   95.69   95.69   95.63   95.63   95.63   95.62   95.62   95.53   95.44   95.44
   95.43   95.43   95.25   95.16   95.07   95.07   94.93   94.89   94.84   94.84
                                                                                
                                                                                
                                                                                
                        
Pier Skew, UpSta & Num, DnSta & Num=  ,3724.538, 2 ,3724.538, 2 , 0 , 0 , 0 ,,
     1.3     1.3
      87   96.37
     1.3     1.3
      87   96.37
Pier Skew, UpSta & Num, DnSta & Num=  ,3756.707, 2 ,3756.707, 2 , 0 , 0 , 0 ,,
     1.3     1.3
   83.98   96.52
     1.3     1.3
   83.98   96.52
Pier Skew, UpSta & Num, DnSta & Num=  ,3788.952, 2 ,3788.952, 2 , 0 , 0 , 0 ,,
     1.3     1.3
   83.57   96.66
     1.3     1.3
   83.57   96.66
Pier Skew, UpSta & Num, DnSta & Num=  ,3821.74, 2 ,3821.74, 2 , 0 , 0 , 0 ,,
     1.3     1.3
   81.17   96.69
     1.3     1.3
   81.17   96.69
Pier Skew, UpSta & Num, DnSta & Num=  ,3885.304, 2 ,3885.304, 2 , 0 , 0 , 0 ,,
     1.3     1.3
    65.6   96.44
     1.3     1.3
    65.6   96.44
Pier Skew, UpSta & Num, DnSta & Num=  ,3917.782, 2 ,3917.782, 2 , 0 , 0 , 0 ,,
     1.3     1.3
   78.22   96.25
     1.3     1.3
   78.22   96.25
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 147
1389.442  100.761497.703   99.861714.223   98.961729.689   98.16 1760.62   98.76
1783.819   98.361853.415   95.261899.812   94.261969.408   94.061984.874   94.36
 1986.42   94.262047.432   93.082063.749   92.76 2094.68   93.662117.879   95.06
2210.673   94.262217.556   94.142248.487   93.582288.002   92.862303.468   93.06
2326.667   92.56 2388.53   92.862465.858   90.462477.612   90.47 2550.92   90.56
2558.653   90.862635.981   89.162759.707   89.162782.906   89.862806.104   89.16
2922.098   91.062983.961   90.063007.159   88.863076.755   88.363107.687   90.06
3130.885   90.163146.351   90.763161.817   90.263185.015   90.763209.451   90.04
3239.145   89.163270.077   88.96 3277.81   88.663293.275   89.163370.604   87.46
3387.307   87.633390.787   87.663418.239   87.613425.971   87.59 3449.17   87.54
3453.732   87.543456.284   87.533495.413   87.943496.959   87.96 3511.49   88.11
3511.574   88.113511.659   88.113534.541   88.343536.629   88.37    3578   88.92
3578.386   88.923616.123   88.973618.211   88.87 3657.88   86.923666.309   86.51
3691.673   87.833697.241   88.123723.687   87.973723.772   87.973723.842   87.97
3723.919   87.97 3724.46   87.973727.322   88.673755.778   85.083756.707   84.96
3788.334   84.573788.952   84.563807.202   83.893820.271    82.6 3821.74   82.45
3846.717   67.173847.104   66.863848.341   66.443852.749   65.843853.522   65.74
3868.833   64.363884.299   66.553885.304   66.593885.691   66.773887.083   69.45
3917.782   79.35 3933.48   83.263949.796   82.993950.338   82.983969.051    87.8
3975.469   87.263982.197   86.943982.267   86.943982.352   86.943982.429   86.93
3997.817   86.214006.316   86.594006.401   86.594006.486   86.594034.471   87.83
4039.034   88.034074.759   88.364075.301   88.364117.368   88.654120.616   88.67
4158.507   89.18 4160.13    89.24198.562   88.734199.259   88.744238.464   89.52
4239.856   90.124240.397   90.364255.863   91.864263.596   93.064279.062   93.36
 4284.32   93.164286.795   93.064292.053   92.454294.528   92.164317.727   92.16
4325.459   92.464340.925   92.564348.658   93.06 4487.85   97.764489.783   97.78
4511.048   97.964541.979   99.264557.445   99.364570.437   99.534611.576  100.06
4634.774  101.66 4650.24  101.664665.706  101.364696.637  103.264882.226  107.86
4951.822  108.364959.555  107.964982.753  109.265021.417  108.965178.086  109.89
5178.163  109.89 5240.49  110.26
BR U #Mann= 5
1389.442     .992047.432     .143727.322     .043975.469     .145178.086     .99
BR D #Sta/Elev= 147
1389.442   98.991497.703   98.091714.223   97.191729.689   96.39 1760.62   96.99
1783.819   96.591853.415   93.491899.812   92.491969.408   92.291984.874   92.59
 1986.42   92.492047.432   91.312063.749   90.99 2094.68   91.892117.879   93.29
2210.673   92.492217.556   92.372248.487   91.812288.002   91.092303.468   91.29
2326.667   90.79 2388.53   91.092465.858   88.692477.612    88.7 2550.92   88.79
2558.653   89.092635.981   87.392759.707   87.392782.906   88.092806.104   87.39
2922.098   89.292983.961   88.293007.159   87.093076.755   86.593107.687   88.29
3130.885   88.393146.351   88.993161.817   88.493185.015   88.993209.451   88.27
3239.145   87.393270.077   87.19 3277.81   86.893293.275   87.393370.604   85.69
3387.307   85.863390.787   85.893418.239   85.843425.971   85.82 3449.17   85.77
3453.732   85.773456.284   85.763495.413   86.173496.959   86.19 3511.49   86.34
3511.574   86.343511.659   86.343534.541   86.573536.629    86.6    3578   87.15
3578.386   87.153616.123    87.23618.211    87.1 3657.88   85.153666.309   84.74
3691.673   86.063697.241   86.353723.687    86.23723.772    86.23723.842    86.2
3723.919    86.2 3724.46    86.23727.322    86.93755.778   83.313756.707   83.19
3788.334    82.83788.952   82.793807.202   82.123820.271   80.83 3821.74   80.68
3846.717    65.43847.104   65.093848.341   64.673852.749   64.073853.522   63.97
3868.833   62.593884.299   64.783885.304   64.823885.691      653887.083   67.68
3917.782   77.58 3933.48   81.493949.796   81.223950.338   81.213969.051   86.03
3975.469   85.493982.197   85.173982.267   85.173982.352   85.173982.429   85.16
3997.817   84.444006.316   84.824006.401   84.824006.486   84.824034.471   86.06
4039.034   86.264074.759   86.594075.301   86.594117.368   86.884120.616    86.9
4158.507   87.41 4160.13   87.434198.562   86.964199.259   86.974238.464   87.75
4239.856   88.354240.397   88.594255.863   90.094263.596   91.294279.062   91.59
 4284.32   91.394286.795   91.294292.053   90.684294.528   90.394317.727   90.39
4325.459   90.694340.925   90.794348.658   91.29 4487.85   95.994489.783   96.01
4511.048   96.194541.979   97.494557.445   97.594570.437   97.764611.576   98.29
4634.774   99.89 4650.24   99.894665.706   99.594696.637  101.494882.226  106.09
4951.822  106.594959.555  106.194982.753  107.495021.417  107.195178.086  108.12
5178.163  108.12 5240.49  108.49
BR D #Mann= 5
1389.442     .992047.432     .143727.322     .043975.469     .145178.086     .99
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=110.26

Type RM Length L Ch R = 1 ,50807   ,304.2,293,424.3
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
     3097399.306    13944263.078     3098048.046    13943826.428
     3098333.736    13942021.608     3098393.376    13940923.058
     3098433.246    13939630.088
#Sta/Elev= 30
1389.442   98.99 1760.62   96.991899.812   92.492047.432   91.312117.879   93.29
2635.981   87.392922.098   89.293076.755   86.593185.015   88.993370.604   85.69
3616.123    87.23666.309   84.743727.322    86.93756.707   83.19 3821.74   80.68
3847.104   65.093868.833   62.593885.304   64.823887.083   67.68 3933.48   81.49
3950.338   81.213969.051   86.033975.469   85.493997.817   84.444238.464   87.75
4263.596   91.294340.925   90.794882.226  106.095178.086  108.12 5240.49  108.49
#Mann= 5 ,-1 , 0
1389.442     .99       02047.432     .14       03727.322    .055       0
3975.469     .14       05178.086     .99       0
#XS Ineff= 2 , 0
       0 3719.73   94.16 3988.28       0   97.08
Permanent Ineff=
       F       F
Bank Sta=3727.322,3975.469
XS Rating Curve= 0
Skew Angle= 39.35
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,50514   ,610.4,542,560.9
BEGIN DESCRIPTION:
Cross Section XS20.2
LOB spills to K120-01-00
END DESCRIPTION:
XS GIS Cut Line= 4
      3098651.89      13942896.5      3098656.46     13941426.68
      3098657.54     13941394.31      3098674.88     13939327.43
#Sta/Elev= 30
  3510.4    91.2  3590.4    92.1  3900.4    92.5  3990.4    95.8  4420.4      96
  4710.4    92.3  4740.4    84.5  4760.4    83.5  4780.4    84.7  4830.4    90.4
  4860.4    90.9  4920.4    86.1  4962.5   71.05  4971.1   65.84  4987.7   63.87
  4993.9   61.66  5005.8   61.82    5040   77.86  5082.7    87.7  5142.7    85.3
  5222.7    84.4  5302.7    85.7  5382.7    90.1  5442.7    90.6  5492.7    88.5
  6032.7    86.2  6162.7    88.5  6282.7    88.1  6692.7    92.8  7079.6    99.8
#Mann= 5 ,-1 , 0
  3510.4     .14       0  3590.4     .06       0  4780.4     .14       0
  4860.4    .055       0  5082.7     .14       0
#XS Ineff= 2 , 0
         4191.41   96.85 5546.88           96.76
Permanent Ineff=
       F       F
Bank Sta=4860.4,5082.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,49972   ,726.4,963,884.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X20A
END DESCRIPTION:
XS GIS Cut Line= 4
      3099208.31     13942495.55      3099260.55     13941490.72
      3099073.62     13941290.44      3099362.25     13939699.84
#Sta/Elev= 30
  3851.7    94.1  4551.7    91.6  4771.7    87.4  4904.5   88.12  4913.4   75.28
  4962.5   71.05  4971.1   64.59  4987.7   62.62  4993.9   60.41  5005.8   60.57
  5012.2   62.68    5040   76.61  5048.3   83.79  5057.9    81.5  5107.9    90.7
  5191.9    90.7  5281.9    87.2  5331.9    82.8  5401.9    83.1  5491.9    79.3
  5511.9      81  5541.9    86.4  5631.9    85.9  5711.9    83.7  5751.9    85.3
  5851.9    85.6  6101.9    95.1  6481.9   106.4  6641.9     110  6748.4   110.5
#Mann= 3 ,-1 , 0
  3851.7     .14       0  4904.5    .055       0  5048.3     .14       0
Bank Sta=4904.5,5048.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,49009   ,723.5,1288,1174.9
BEGIN DESCRIPTION:
Cross Section XS20.1
END DESCRIPTION:
XS GIS Cut Line= 6
      3099227.41      13942664.7      3099894.82     13941594.62
      3099994.78     13941026.69      3100011.11     13940964.11
      3100058.93     13940603.63      3099857.24     13939783.46
#Sta/Elev= 30
  3120.3    94.5  3560.3    92.8  3810.3    89.8  3930.3    90.4  4070.3    89.2
  4180.3    90.2  4280.3    88.4  4350.3    89.1  4491.5    86.4  4551.5    86.9
  4641.5    89.8  4721.5    90.2  4781.5    88.3  4841.5    84.4  4881.5      80
  4931.5    77.3  4962.5   69.06  4971.1    62.6  4987.7   60.63  4993.9   58.42
  5005.8   58.58  5012.2   60.69    5040   74.62  5072.8    79.1  5102.8    84.8
  5132.8    86.2  5252.8    83.8  5362.8    85.1  5866.4   101.4    6231   106.2
#Mann= 3 , 0 , 0
  3120.3     .14       0  4721.5    .055       0  5102.8     .14       0
Bank Sta=4721.5,5102.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,47721   ,2582.9,1600,1645.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X20
END DESCRIPTION:
XS GIS Cut Line= 4
      3099583.94      13942372.4      3101092.64     13941621.12
      3101099.09     13941302.13       3101332.8     13940063.16
#Sta/Elev= 30
  3097.3    92.4  3227.3      91  3297.3    91.8  3597.3    88.3  3807.3    87.6
  4017.3    90.6  4167.3    86.2  4417.3    87.2  4467.3    88.8  4677.3    88.7
  4842.7    84.9  4882.7    79.9  4884.4   78.67  4936.8   80.52  4956.6   69.88
  4979.7   55.76  5000.1    56.5  5030.5   61.95  5047.8   71.69  5080.1   80.97
  5118.4   83.15  5141.8    80.6  5161.8    79.9  5231.8    83.5  5371.8    85.3
  5431.8    84.2  5501.8    86.4  5831.8    90.4  6201.8     103  6362.6   106.1
#Mann= 3 ,-1 , 0
  3097.3     .14       0  4936.8    .055       0  5080.1     .14       0
Bank Sta=4936.8,5080.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,46121   ,375,525,521.7
BEGIN DESCRIPTION:
Cross Section XS19.2
This is known levee system and it provides sufficient protection from the 1% chance flood.
END DESCRIPTION:
XS GIS Cut Line= 4
      3104022.07     13944438.54       3102383.8     13942542.27
      3102424.01     13941930.51      3102502.47     13940354.46
#Sta/Elev= 30
    2110   94.66  3111.6   91.97    3313   93.07  3391.7   87.29  3681.7   83.31
  4251.7   88.52  4451.7   86.72  4551.7   88.05  4601.7   93.12  4637.7    93.2
  4777.7   86.26 4902.72    82.5 4957.82   68.97 4970.59   59.72 4979.25   56.48
 5026.74    59.7 5039.99   67.64 5115.83   84.02  5157.7   85.86  5187.7   92.94
  5207.7   93.65  5260.7    83.8  5490.7   85.45  5580.7   81.46  5950.7   84.32
  6490.7   95.11  6610.7   99.11  6730.7  100.74  6790.7   99.49  6828.7  102.13
#Mann= 4 ,-1 , 0
    2110      .1       0 4902.72    .055       0 5115.83    .055       0
  5207.7     .99       0
Levee=0,,,-1,5197.7,93.85,,Levee 2
#XS Ineff= 2 , 0
         3333.01   94.76
Permanent Ineff=
       F       F
Bank Sta=4902.72,5115.83
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,45596   ,1343.3,1188,1125.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X19
This is known levee system and it provides sufficient protection from the 1% chance flood.
END DESCRIPTION:
XS GIS Cut Line= 4
      3104048.47     13944453.79      3102931.59     13942550.93
      3102923.95     13941922.82      3102896.93     13940469.58
#Sta/Elev= 30
    2485    95.7  2847.7   94.72  2942.1   92.83  3767.7   91.89    3795    87.8
    4025    83.8    4265    82.3  4891.6   83.14  4954.6   70.85  4969.2   60.02
  4979.1   56.71  5030.7   59.89  5045.1   69.86  5127.5   85.02  5161.4    85.6
  5191.4      92  5221.4    92.9  5251.4    85.8  5311.4    82.5  5489.6    81.4
  5559.6    83.2  5719.6    83.4  5819.6    82.2  5859.6    84.5  6069.6      87
  6349.6    87.3  6439.6      92  6489.6    89.6  6559.6    95.4  6773.1   100.5
#Mann= 4 ,-1 , 0
    2485     .14       0  4891.6    .055       0  5127.5     .06       0
  5221.4     .99       0
Levee=0,,,-1,5211.4,93.4,,Levee 2
#XS Ineff= 2 , 0
         3713.87   94.76
Permanent Ineff=
       F       F
Bank Sta=4891.6,5127.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,44408   ,1904.6,1922,1913.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X18C-INTERP
This is known levee system and it provides sufficient protection from the 1% chance flood.
END DESCRIPTION:
XS GIS Cut Line= 4
      3104134.88     13944431.38      3104171.39     13942076.54
      3103903.65     13941681.02      3103526.39     13939575.66
#Sta/Elev= 30
    2383    97.2    3187    90.2  3733.7   90.76  3833.7   91.59    3847      94
  3853.7   90.93 4237.58   90.69    4396    93.6 4405.91   90.71    4483    89.4
 4679.34   90.71 4700.05   84.03 4880.72   83.36 4945.74   71.34 4981.21   58.39
    5000    55.6 5041.01   65.58 5054.12   72.11 5129.14   83.83  5178.8   92.51
  5208.8   91.21  5238.8   83.36  5336.4   81.73  5776.4   86.07  6176.4   81.99
  6266.4   86.36  6546.4   87.11  6686.4   92.83  7156.4   95.98  7395.3   101.1
#Mann= 4 ,-1 , 0
    2383      .1       0 4880.72    .055       0 5129.14    .055       0
  5208.8     .99       0
Levee=0,,,-1,5198.8,93.14,,Levee 2
#XS Ineff= 2 , 0
         4332.03   93.69
Permanent Ineff=
       F       F
Bank Sta=4880.72,5129.14
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,42486   ,178.2,469,515
BEGIN DESCRIPTION:
Cross Section K100-00-00-X18B
This is known levee system and it provides sufficient protection from the 1% chance flood.
END DESCRIPTION:
XS GIS Cut Line= 4
      3104241.93     13944400.96      3105200.01     13940494.22
      3104725.84     13940143.21      3104128.52     13939490.47
#Sta/Elev= 30
   599.7    96.9  1239.7    89.6  1884.2    92.7  1929.7    89.9  1978.2      94
  2199.7    90.6  2413.2    93.5  2459.7    90.6  2512.2    94.5  2529.7    90.4
  2636.2    93.8  2919.7   90.96  3140.2    93.2  3366.2    88.7  4317.2    91.6
  4344.2    88.2  4500.4   86.36  4542.2    89.8  4622.2    84.3  4863.1   83.72
  4952.1   68.08  4972.5   59.41  5018.2   53.81  5052.7   74.36  5131.8    81.9
  5212.1    92.5  5272.1    84.7  5362.1    90.2  5682.1    98.6  6096.9   104.9
#Mann= 6 ,-1 , 0
   599.7     .14       0  2919.7     .06       0  4500.4     .14       0
  4863.1    .055       0  5131.8    .055       0  5212.1     .99       0
Levee=0,,,-1,5212.04,92.5,,Levee 2
#XS Ineff= 2 , 0
         4231.45   93.28
Permanent Ineff=
       F       F
Bank Sta=4863.1,5131.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,42017.  ,129.2,321,426
BEGIN DESCRIPTION:
K100-00-00-S7_HARDY TOLL RD SB -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 5
      3104390.92      13944208.3      3105266.34     13940860.16
      3105376.13     13940170.72      3105167.16     13939832.45
      3105240.52     13938576.79
#Sta/Elev= 30
   616.2   96.05  818.34    95.3  1026.2   90.51 1318.34    89.6 2147.34    94.5
 2870.34    92.7 3136.04    88.8  3386.2    90.7 3512.34    92.4 3848.34    90.5
 4073.34    93.2  4076.9   89.43 4113.29    88.8 4449.34    87.2  4805.1   82.35
  4875.1   83.61  4935.1   73.33 4979.55   59.12 5007.34   55.67 5035.43   66.14
  5115.1   83.49  5155.1   82.35  5362.7   92.11  5712.7  100.52  5752.7   97.36
  5782.7   91.89  5802.7   93.96  5832.7   98.32  6072.7   98.23  6430.5  103.99
#Mann= 6 ,-1 , 0
   616.2     .14       0  3386.2     .06       0 4449.34     .12       0
  4875.1    .055       0  5115.1     .14       0  5802.7      .1       0
#XS Ineff= 2 , 0
         3690.31   93.09
Permanent Ineff=
       F       F
Bank Sta=4875.1,5115.1
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,41696   ,118.2,118,119.8
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
      3104517.21     13944226.19      3105392.64       13940878.
 3105754.265862413938659.6460011
#Sta/Elev= 30
   533.6    96.1   743.6    95.7  1083.6    88.9  1613.6    89.6  1683.6    90.6
  1701.3    93.9  1723.6      91  1913.6    89.3  2624.3    93.4  2853.6    92.1
  3998.3    87.9  4204.3    80.9 4235.06   86.62  4304.3   86.93  4651.8   88.56
  4677.6   81.54  4881.4   80.83  4948.6   77.17  4980.9   59.37  5001.3   56.99
  5021.3   58.99  5073.6   77.23  5141.5   77.26  5223.9   82.07  5249.3    89.7
  5584.3    86.8  5634.3    91.4  5734.3    89.4  5974.3    94.3    6242   97.13
#Mann= 7 ,-1 , 0
   533.6     .99       0  2853.6     .06       0  3998.3    .055       0
  4304.3     .06       0  4948.6    .055       0  5073.6     .06       0
  5974.3     .99       0
#XS Ineff= 2 , 0
       0 4005.86    92.7    5256       0      95
Permanent Ineff=
       F       F
#Block Obstruct= 2 , 0
       0                  5249.3       0    89.5
Bank Sta=4948.6,5073.6
XS Rating Curve= 0
Exp/Cntr=.5,.3
