HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 3 ,160197  ,,,
BEGIN DESCRIPTION:
TELGE
Structure ID: K100-00-00-S23
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,76,2.6,0, 154, 154, , , .95, 0, ,,,
   681.1   751.1   761.2   781.1   801.1  1141.1  1201.1  1271.1  1501.1  1761.1
  1921.1  1981.1  2741.1  2781.1  2981.1  3151.1  3261.1  3271.1  3321.1  3411.1
  3781.1  3831.1  3852.3  3950.6  4012.3  4022.3  4031.1  4111.1  4332.3  4401.1
  4411.1  4441.1  4481.1  4552.3  4561.1  4572.3  4599.9  4801.2  4855.7 4871.29
  4871.4 4871.51  4918.4 4920.01  4920.1  4937.5  4937.6  4951.1  4969.5  4971.5
  4982.6  4984.5  4985.2  4998.1    5011  5012.1  5015.6    5016  5038.6  5051.8
  5052.6  5052.7  5068.2 5069.49  5069.6 5091.69  5091.8 5091.91  5123.2  5176.6
  5232.6  5374.2  5544.2    5550    5570    5580  5594.2  5654.2  5694.2    5730
  5884.2    5910  5914.2    5960  5994.2    6140  6184.2    6360  6518.3    6520
  6557.1    6570    6580    6640    6650  6654.2    6700  6894.2    6950  7037.1
  7061.7    7260    7310    7340  7491.7  7531.7    7540    7670    7680    7690
    7700    7730    7760  7765.4    7770    7780    7790    7820    7840    7870
    7890    7910    7920    8350    8450    8540    8690    8720    8740    8790
    8800    8810    8840    8890    9050    9060    9080    9100    9130    9530
    9600    9640    9730    9920   10190   10260   10450   10490   10510   10530
   10580   10600   10630 10635.4
   142.5   141.2  141.33   141.6   140.7   141.3   141.8   140.9   141.4   140.8
   141.8   140.3   139.6   139.9   138.7   138.6   137.7   137.3   138.4   137.1
   137.9   137.4  137.39  137.29  137.23   137.3  137.24  137.01   136.9  136.59
  136.54  136.41  136.22   135.9  136.12   136.4   136.3  138.76  139.34  139.44
  142.24  142.24  142.56  142.57  142.57  142.66  142.66  142.74  142.84  142.85
  142.84  142.84  142.84  142.84  142.83  142.83  142.82  142.81  142.72  142.67
  142.66  142.66   142.6  142.59  142.59  142.48  142.48  139.68  139.31  138.77
  138.21     137   137.1  137.07  136.95  136.89   136.8     137   136.3  136.49
   137.3  136.87   136.8   137.2   137.5   137.5   137.5  137.09  136.72  136.71
  136.63   136.6  136.57  136.43  136.41   136.4  136.57   137.3  137.03  136.62
   136.5  136.78  136.85  136.89   137.1   137.2  137.15  136.43  136.71  136.41
  136.26  136.61  135.93   135.9   135.2   135.3   136.3   136.8   137.5   137.4
   137.7   138.6   138.1   137.8   136.3   136.7   136.4   135.4   136.6   136.5
   136.1   134.8   136.3   136.6   135.9   135.1   134.3   134.6   135.9     137
   138.2   137.1   139.3   139.3   138.4   136.8     137     136   136.4   137.5
   138.1   140.5   147.3   142.8
                                                                                
                                                                                
                                                                                
                                                                                
                                  136.77  136.86  136.86  136.94  137.04  137.05
  137.04  137.04  137.04  137.04  137.03  137.03  137.02  137.01  136.92  136.87
  136.86  136.86   136.8  136.79  127.65
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                
   681.1   751.1   761.2   781.1   801.1  1141.1  1201.1  1271.1  1501.1  1761.1
  1921.1  1981.1  2741.1  2781.1  2981.1  3151.1  3261.1  3271.1  3321.1  3411.1
  3781.1  3831.1  3852.3  3950.6  4012.3  4022.3  4031.1  4111.1  4332.3  4401.1
  4411.1  4441.1  4481.1  4552.3  4561.1  4572.3  4599.9  4801.2  4855.7 4871.29
  4871.4 4871.51  4918.4 4920.01  4920.1  4937.5  4937.6  4951.1  4969.5  4971.5
  4982.6  4984.5  4985.2  4998.1    5011  5012.1  5015.6    5016  5038.6  5051.8
  5052.6  5052.7  5068.2 5069.49  5069.6 5091.69  5091.8 5091.91  5123.2  5176.6
  5232.6  5374.2  5544.2    5550    5570    5580  5594.2  5654.2  5694.2    5730
  5884.2    5910  5914.2    5960  5994.2    6140  6184.2    6360  6518.3    6520
  6557.1    6570    6580    6640    6650  6654.2    6700  6894.2    6950  7037.1
  7061.7    7260    7310    7340  7491.7  7531.7    7540    7670    7680    7690
    7700    7730    7760  7765.4    7770    7780    7790    7820    7840    7870
    7890    7910    7920    8350    8450    8540    8690    8720    8740    8790
    8800    8810    8840    8890    9050    9060    9080    9100    9130    9530
    9600    9640    9730    9920   10190   10260   10450   10490   10510   10530
   10580   10600   10630 10635.4
   142.5   141.2  141.33   141.6   140.7   141.3   141.8   140.9   141.4   140.8
   141.8   140.3   139.6   139.9   138.7   138.6   137.7   137.3   138.4   137.1
   137.9   137.4  137.39  137.29  137.23   137.3  137.24  137.01   136.9  136.59
  136.54  136.41  136.22   135.9  136.12   136.4   136.3  138.76  139.34  139.44
  142.24  142.24  142.56  142.57  142.57  142.66  142.66  142.74  142.84  142.85
  142.84  142.84  142.84  142.84  142.83  142.83  142.82  142.81  142.72  142.67
  142.66  142.66   142.6  142.59  142.59  142.48  142.48  139.68  139.31  138.77
  138.21     137   137.1  137.07  136.95  136.89   136.8     137   136.3  136.49
   137.3  136.87   136.8   137.2   137.5   137.5   137.5  137.09  136.72  136.71
  136.63   136.6  136.57  136.43  136.41   136.4  136.57   137.3  137.03  136.62
   136.5  136.78  136.85  136.89   137.1   137.2  137.15  136.43  136.71  136.41
  136.26  136.61  135.93   135.9   135.2   135.3   136.3   136.8   137.5   137.4
   137.7   138.6   138.1   137.8   136.3   136.7   136.4   135.4   136.6   136.5
   136.1   134.8   136.3   136.6   135.9   135.1   134.3   134.6   135.9     137
   138.2   137.1   139.3   139.3   138.4   136.8     137     136   136.4   137.5
   138.1   140.5   147.3   142.8
                                                                                
                                                                                
                                                                                
                                                                                
                                  136.77  136.86  136.86  136.94  137.04  137.05
  137.04  137.04  137.04  137.04  137.03  137.03  137.02  137.01  136.92  136.87
  136.86  136.86   136.8  136.79  127.65
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4970, 2 ,4970, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  116.25  138.05
     1.5     1.5
  117.71  139.52
Pier Skew, UpSta & Num, DnSta & Num=  ,5020, 2 ,5020, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  116.34     138
     1.5     1.5
  117.81  139.47
Abutment Skew #Up #Dn= , 2 , 2
  4919.9  4937.6
  136.77  126.89
  4919.9  4937.6
  136.77  126.89
Abutment Skew #Up #Dn= , 2 , 2
  5052.7 5069.69
   127.5  136.79
  5052.7 5069.69
   127.5  136.79
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=147.3

Type RM Length L Ch R = 1 ,160148  ,117.8,106,113.5
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3028664.69     13913454.88      3029613.91     13909554.07
      3029568.53     13908865.11      3029215.41     13903621.61
#Sta/Elev= 30
     679  142.13    3999  136.97  4693.6  133.35  4913.6  136.07  4951.1  128.11
  4969.5  118.82    5011  114.78  5038.6  128.18  5063.6  128.31  5083.6  133.44
  5283.6  131.79  5664.1  136.69  5844.1  135.58  5994.1  130.12  6094.1  133.99
  6294.1  132.18  6464.1  136.92  6534.1  132.53  6574.1  130.05  6624.1   134.5
  7024.1  134.88  7714.1  135.03  7974.1  138.57  8914.1  133.97  8964.1  136.53
  9014.1  134.29 10214.1  138.85 10564.1  136.09 10634.1  138.49 10639.5  143.52
#Mann= 6 ,-1 , 0
     679     .99       0    3999     .24       0  4913.6   .0188       0
  5083.6     .24       0  6534.1      .2       0  7024.1     .99       0
#XS Ineff= 2 , 0
       0 4906.25  136.25 5093.75       0  136.16
Permanent Ineff=
       F       F
Bank Sta=4913.6,5083.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,160042. ,315.1,278,305.3
BEGIN DESCRIPTION:
K100-00-00-S23_TELGE RD -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3028736.12      13913453.3      3029719.48     13909551.13
       3029674.1     13908862.18      3029320.98     13903618.68
#Sta/Elev= 30
   675.4  141.54   735.4  139.85   995.4   141.5  2485.4  139.94  3055.4  136.53
  4145.4  138.25  4749.7  128.34  4939.7  130.12 4974.16  118.14    5011  114.57
  5035.4  126.42  5049.7  130.11  5900.1  130.86  6020.1  136.55  6200.1  137.93
  6480.1  136.03  6570.1  132.03  6600.1  134.73  6650.1  132.75  7450.1  136.09
  7750.1  134.38  7870.1  137.82  7890.1  136.23  8880.1  136.94  8970.1  134.13
  9060.1  136.37  9650.1  138.48 10150.1  138.88 10630.1  136.12 10640.1  140.54
#Mann= 5 ,-1 , 0
   675.4     .99       0  4145.4     .24       0  4939.7   .0525       0
  5049.7     .24       0  6480.1      .2       0
#XS Ineff= 2 , 0
        4796.984  136.255228.895        136.1628
Permanent Ineff=
       F       F
Bank Sta=4939.7,5049.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,159764  ,1104,1295,1501.6
BEGIN DESCRIPTION:
Cross Section XS48.2
END DESCRIPTION:
XS GIS Cut Line= 5
      3028794.48      13913461.7      3029966.55     13909997.95
      3029972.97     13909330.53      3029972.97     13909191.98
      3029802.08      13903511.6
#Sta/Elev= 30
     619     142     689   140.1    2529   139.4    3049     135    3559   137.5
    3609   135.1    3699   138.6    3929   137.8    4089     135    4239   136.7
  4375.7   133.5  4415.7   136.2  4525.7   136.6  4695.7   130.8  4895.7   130.7
  4953.1     127  4969.5  118.07    5011  114.03  5038.6  127.43  5053.1   130.4
  5971.7   130.6  7601.7   134.3  7691.7   136.8  8871.7   135.8  8911.7   133.4
  8921.7   135.5  8991.7   136.5  9721.7   137.8 10411.7   135.8 10764.6   137.8
#Mann= 7 ,-1 , 0
     619     .99       0    3929      .2       0  4375.7     .28       0
  4895.7   .0525       0  5053.1     .28       0  5971.7     .24       0
  7601.7     .99       0
#XS Ineff= 2 , 0
         4510.42  136.25 5583.33          136.17
Permanent Ineff=
       F       F
Bank Sta=4895.7,5053.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,158469  ,1359.9,1588,1045.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X48
END DESCRIPTION:
XS GIS Cut Line= 4
      3028975.78     13913374.24      3031222.44      13909645.1
      3031298.85     13909033.77      3032980.02     13906817.68
#Sta/Elev= 30
   386.9   140.4   556.9   141.9  1916.9     140  2036.9   136.7  2076.9   138.9
  2276.9   138.4  2656.9   134.8  3256.9     137  3521.2  132.88  3606.9   134.4
  4396.9   129.9  4952.1  129.89  4981.5  120.21  4986.6  112.85  4999.4  111.27
  5013.5  112.84  5021.7  123.28  5041.6  128.78  5050.5     125  5090.5   124.7
  5120.5   127.9  5300.5   129.5  6012.4  132.13  6326.6     136  7196.6     137
  7676.6   134.6  7716.6   136.9  7776.6   135.4  7896.6   137.2  8138.2   135.3
#Mann= 6 ,-1 , 0
   386.9     .99       0  3521.2     .28       0  4952.1   .0525       0
  5041.6     .28       0  6012.4      .2       0  6326.6     .99       0
#Block Obstruct= 2 ,-1
    2616  2776.7   136.5    6788    8141     137
Bank Sta=4952.1,5041.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,156881  ,396.9,1056,1337.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X47
END DESCRIPTION:
XS GIS Cut Line= 4
      3029342.58     13913328.39      3032292.27     13910684.37
      3032017.17     13909813.22      3033285.69      13906985.8
#Sta/Elev= 30
   493.8   140.4  1873.8   139.8  2463.8     135  2613.8   136.7  2913.8   134.5
  2983.8   130.7  3113.8   135.1    3506  132.36  3783.8   129.5  4655.1   127.5
  4825.1   130.7    4965  128.35  4991.6  111.02  5000.5  110.96  5008.4  111.97
  5014.2  118.35  5027.3  124.41  5075.1   128.4  5135.1   126.8  5205.1   129.7
  6098.6   135.8  6988.6     137  7068.6   134.7  7088.6   137.2  7528.6   136.4
  7928.6   139.9  8098.6   138.4  8118.6     134  8158.6   137.1  8467.5     135
#Mann= 5 ,-1 , 0
   493.8     .99       0    3506     .24       0    4965    .045       0
  5027.3     .24       0  6098.6     .99       0
#Block Obstruct= 2 ,-1
    2926    3044  134.32    6824    8500   136.8
Bank Sta=4965,5027.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,155825  ,975,1148,694
BEGIN DESCRIPTION:
Cross Section K100-00-00-X46
END DESCRIPTION:
XS GIS Cut Line= 4
      3028929.93     13914184.26      3032781.34     13910730.22
      3032980.02      13910745.5      3034630.63     13907918.08
#Sta/Elev= 30
  -298.8   140.4   191.2   142.6   541.2   139.1   781.2   141.9   841.2   139.4
  1651.2   138.6  1691.2   135.8  1861.2   138.8  2011.2     136  2561.2   136.9
  2681.2   135.8  2721.2   127.5  2761.2   136.4  3601.2   133.8  3871.2   128.5
  4071.2   130.8  4171.2   127.8  4311.2   130.4  4944.6   126.8  4945.3  123.58
  4967.6  122.11  4991.9  110.33    5010  111.53  5023.6  121.03  5032.7  131.79
  5113.8   126.7  5752.9  131.57  7033.8   136.8  7843.8   138.1  8347.8   135.5
#Mann= 6 ,-1 , 0
  -298.8     .99       0  3601.2     .24       0  4944.6    .045       0
  5032.7     .24       0  5752.9      .2       0  7033.8     .99       0
#Block Obstruct= 2 ,-1
    2671    2765  136.42    5000  5000.1      50
Bank Sta=4944.6,5032.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,154677  ,1008.6,950,393.7
BEGIN DESCRIPTION:
Cross Section K100-00-00-X45
END DESCRIPTION:
XS GIS Cut Line= 4
      3029342.58     13915101.26      3032964.74     13911830.62
      3033224.56     13911555.52      3034966.86     13908101.48
#Sta/Elev= 30
   -69.8   140.4   730.2   141.7  1800.2   137.3  1830.2   139.2  1860.2   136.9
  2030.2   139.2  2300.2   136.9  2990.2   139.4  3820.2   135.2  3950.2   132.2
    4122  134.51  4270.2   130.3  4660.2   128.2  4720.2   122.9  4830.5   120.7
  4890.5     122  4898.6  124.38  4968.7  123.95  4985.3   111.8    5001  109.27
  5014.7  111.07  5019.8  119.71    5036  128.99  5180.5   130.5  5328.9   128.1
  5418.9   131.1  5998.9   128.3  6478.9   133.7  8778.9   137.4  9057.5   135.3
#Mann= 5 ,-1 , 0
   -69.8     .99       0    4122     .28       0  4968.7    .045       0
    5036     .28       0  6478.9     .99       0
Bank Sta=4968.7,5036
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,153727  ,415.1,1392,772.1
BEGIN DESCRIPTION:
Cross Section K100-00-00-X44
END DESCRIPTION:
XS GIS Cut Line= 4
       3029694.1     13915987.69      3033499.66     13912686.49
      3033499.66     13911891.76      3035043.28     13908132.05
#Sta/Elev= 30
  -282.6   139.4  1667.4     139  1907.4   137.3  2217.4   138.8  2257.4   137.2
  2377.4   138.5  2437.4   135.6  2457.4   137.9  3677.1  136.57  3837.4   135.6
  3907.4   132.6  4027.4     135  4137.4   132.2  4417.4   132.3  4973.2  126.43
  4980.9  116.01  4990.7  110.48  5000.8  108.66  5009.1  110.69  5031.4  125.36
  5135.3   131.7  5215.3   127.8  5515.3   127.7    5550     130    5710   127.7
    6150   128.5    6390   129.3    6520   133.2  6763.5  135.69  9614.3   135.2
#Mann= 5 ,-1 , 0
  -282.6     .99       0  3677.1     .28       0  4973.2    .045       0
  5031.4     .24       0  6763.5     .99       0
Bank Sta=4973.2,5031.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,152335  ,650.7,1021,651.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X44A
END DESCRIPTION:
XS GIS Cut Line= 5
      3029862.22     13916553.18      3033790.04     13913007.44
      3034156.84     13911876.47      3034569.49     13911494.39
      3035134.98      13908086.2
#Sta/Elev= 30
 -1582.9   138.1   407.1   140.3   727.1   139.5   797.1     137   897.1   139.5
  1237.1   136.4  1927.1     139  2437.1   135.3  3277.1   134.6  3707.1   127.1
  3858.6   128.5  3908.6   126.4  4208.6   128.7  4498.6   125.4  4838.6   129.4
  4897.6   128.3  4928.6  124.49  4961.8  123.56  4977.4  117.42  4993.4  107.89
  5013.9  111.38  5024.2  120.18  5049.2  122.29    5059  127.05  5397.6   128.2
  6059.9   135.6  6859.9   132.8  7179.9   136.6  7749.9     134  8914.7   135.2
#Mann= 5 ,-1 , 0
 -1582.9     .99       0  3277.1     .28       0  4961.8    .045       0
    5059     .24       0  6059.9     .99       0
Bank Sta=4961.8,5059
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,151314. ,97.8,100,101.9
BEGIN DESCRIPTION:
K100-00-00-S22_HUFFMEISTER -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3030043.91      13917279.7      3034853.03     13912815.55
      3035039.88     13912120.14       3035194.4     13908170.91
#Sta/Elev= 30
 -1999.2  140.48 -1209.2  139.06  -809.2  134.99  -669.2  137.41  -649.2  135.64
   120.8  135.21  1680.8  136.74  3110.8  127.75  3250.8  128.24  3290.8  130.69
  3430.8  128.06  3720.8   127.3  4290.8   129.1  4550.8  126.39  4822.6  128.85
  4932.6  126.47  4962.6  122.52 4978.95  118.44 4979.23  115.44 4990.34  111.17
 5000.87  110.17  5072.6  127.45  5142.6  122.52  5192.6  127.22  5682.7  127.61
  5882.7  131.77  6392.7  136.17  7322.7  132.78  7732.7  135.23  9234.9  134.52
#Mann= 5 ,-1 , 0
 -1999.2     .99       0  1680.8     .24       0  4932.6    .045       0
  5072.6     .24       0  6392.7     .99       0
Bank Sta=4932.6,5072.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,151214  ,60,61,84.4
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3030134.81     13917315.34      3034943.93     13912851.09
      3035130.78     13912155.69       3035285.3     13908206.46
#Sta/Elev= 30
 -1983.6  139.98 -1383.6  139.38  -803.6  133.98  -673.6  137.08   105.3  134.98
  1026.4  136.88  1056.4  134.68  1645.3  136.93  2666.4  129.38  3696.4  126.38
  3862.9  128.57  4446.4  128.58  4506.4  124.88  4576.4  129.08  4708.2  127.88
  4718.8  131.64  4927.5  132.34  4978.5  118.88  4978.8   115.6  4990.5  111.25
  5001.6  110.39  5034.8  120.01  5105.2  132.68  5508.3  126.28  5978.3  130.98
  6048.3  129.68  6388.3  135.28  7068.3  132.58  7778.3  134.98  9250.5  134.08
#Mann= 6 ,-1 , 0
 -1983.6     .99       0  1645.3     .24       0  3862.9     .28       0
  4927.5    .045       0  5105.2     .24       0  6388.3     .99       0
#XS Ineff= 2 , 0
       0  4917.5   126.6  5115.2       0   127.4
Permanent Ineff=
       F       F
Bank Sta=4927.5,5105.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,151185  ,,,
BEGIN DESCRIPTION:
HUFFMEISTER
Structure ID: K100-00-00-S22
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,38,2.6,0, 60, 60, , , .95, 0, ,,,
 -1983.6 -1943.6 -1903.6 -1843.6 -1383.6  -803.6  -684.7  -534.7  -474.7  -454.7
  -444.7  -294.7  -184.7  -144.7   -84.7    15.3    95.3   115.3   235.3   325.3
   365.3   396.4   416.4   546.4   596.4   626.4  1026.4  1056.4  1076.4  1276.4
  1636.4  2386.4  2925.3  3575.3  3685.3  3905.3  4466.4 4891.49  4891.6  4936.7
 4936.79  4978.5  5086.2  5086.3  5131.1 5131.21  5201.5  5497.6  5717.6  6228.3
  6238.3  6358.3  6388.3  6637.6  7778.3  8168.3  8748.3  9028.3  9058.3  9250.5
     140   140.4   138.9   140.2  139.41  134.76   137.6   136.6   137.4  136.26
   137.2   136.2     137  135.53   136.6  135.12   136.4  135.03   136.1  135.49
   136.6  135.81  137.01  136.71  135.11  136.21  136.91  134.71  136.41  135.31
  137.01  130.81  128.61     128   126.6     129  128.63  133.24  135.34  135.52
  135.52  135.54  135.53  135.52  134.81  132.71  131.13   127.4   127.9  132.54
  133.81  133.28  135.31   134.3  135.01   133.4   135.4   133.7   134.7   134.1
                                                                                
                                                                                
                                                                                
                                                                                
  131.02  131.04  131.03
                                                                                
 -1983.6 -1943.6 -1903.6 -1843.6 -1383.6  -803.6  -684.7  -534.7  -474.7  -454.7
  -444.7  -294.7  -184.7  -144.7   -84.7    15.3    95.3   115.3   235.3   325.3
   365.3   396.4   416.4   546.4   596.4   626.4  1026.4  1056.4  1076.4  1276.4
  1636.4  2386.4  2925.3  3575.3  3685.3  3905.3  4466.4 4891.49  4891.6  4936.7
 4936.79  4978.5  5086.2  5086.3  5131.1 5131.21  5201.5  5497.6  5717.6  6228.3
  6238.3  6358.3  6388.3  6637.6  7778.3  8168.3  8748.3  9028.3  9058.3  9250.5
     140   140.4   138.9   140.2  139.41  134.76   137.6   136.6   137.4  136.26
   137.2   136.2     137  135.53   136.6  135.12   136.4  135.03   136.1  135.49
   136.6  135.81  137.01  136.71  135.11  136.21  136.91  134.71  136.41  135.31
  137.01  130.81  128.61     128   126.6     129  128.63  133.24  135.34  135.52
  135.52  135.54  135.53  135.52  134.81  132.71  131.13   127.4   127.9  132.54
  133.81  133.28  135.31   134.3  135.01   133.4   135.4   133.7   134.7   134.1
                                                                                
                                                                                
                                                                                
                                                                                
  131.02  131.04  131.03
                                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4986.1, 2 ,4986.1, 2 , 0 , 0 , 0 ,,
     1.4     1.4
  113.19  132.04
     1.4     1.4
  113.77  132.62
Pier Skew, UpSta & Num, DnSta & Num=  ,5036.5, 2 ,5036.5, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   119.2  132.02
     1.4     1.4
  119.78   132.6
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=140.38

Type RM Length L Ch R = 1 ,151153  ,89.7,96,130.6
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3030187.61     13917338.04      3035000.95     13912869.87
      3035189.88     13912166.75      3035344.48     13908215.28
#Sta/Elev= 30
 -1983.6  140.54 -1383.6  139.94  -803.6  134.54  -673.6  137.64   105.3  135.54
  1026.4  137.44  1056.4  135.24  1645.3  137.49  2666.4  129.94  3696.4  126.94
  3862.9  129.13  4446.4  129.14  4506.4  125.44  4576.4  129.64  4708.2  128.44
  4718.8   132.2  4927.5   132.9  4978.5  119.44  4978.8  116.16  4990.5  111.81
  5001.6  110.95  5034.8  120.57  5105.2  133.24  5508.3  126.84  5978.3  131.54
  6048.3  130.24  6388.3  135.84  7068.3  133.14  7778.3  135.54  9250.5  134.64
#Mann= 6 ,-1 , 0
 -1983.6     .99       0  1645.3     .24       0  3862.9     .28       0
  4927.5    .045       0  5105.2     .24       0  6388.3     .99       0
#XS Ineff= 2 , 0
       0 4920.83   126.6 5111.87       0   127.4
Permanent Ineff=
       F       F
Bank Sta=4927.5,5105.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,151057. ,883.8,1353,1033.4
BEGIN DESCRIPTION:
K100-00-00-S22_HUFFMEISTER -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3030278.84      13917360.6      3035092.17     13912892.47
       3035281.1     13912189.34       3035435.7     13908237.87
#Sta/Elev= 30
 -1977.4  138.85  -777.4  134.18  -727.4  137.01  -507.4  134.09  -337.4  136.99
  -177.4  133.21  -147.4  136.15  -117.4  133.89   952.6  136.81  2952.6   126.5
  2992.6  129.55  3062.6  127.12  3482.6  128.71  3502.6  125.76  3622.6  128.56
  3752.6  125.54  3872.6  128.18  4362.6  127.05  4830.1  124.77  4880.1  129.49
  4940.1  126.62  4970.1  121.85  4990.1  112.97  5000.1  111.96  5020.1  112.19
  5050.1  125.64  5110.1  128.28  5358.2  126.32  6688.2  135.64  9272.7  135.71
#Mann= 5 ,-1 , 0
 -1977.4     .99       0   952.6     .24       0  4362.6     .28       0
  4940.1    .045       0  5050.1     .24       0
Bank Sta=4940.1,5050.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,149704  ,473.9,690,794.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X43
END DESCRIPTION:
XS GIS Cut Line= 4
      3032796.62      13917363.2      3035532.34     13913389.52
      3035792.16     13913420.09      3036632.74     13909614.54
#Sta/Elev= 30
    91.2   140.7   131.2   131.7   201.2   138.7   331.2   140.3  1214.2  134.13
  2731.2   136.2  3827.9  127.65  4191.2     127  4311.2     122  4604.7   125.5
  4771.2   124.3  4943.7  128.99  4961.3  126.49  4974.3  120.91  4990.4  106.94
  5001.5  105.22  5010.4  108.21  5021.4   118.5    5036  120.55  5039.1  120.67
  5101.6  118.27  5155.5   130.6  5457.1   126.3  6473.4  131.85  6557.1   135.2
  6917.1   136.4  7877.1   133.7  8217.1   136.3  8987.1   132.5  9074.4   135.2
#Mann= 8 ,-1 , 0
    91.2     .99       0  1214.2     .28       0  3827.9     .24       0
  4604.7     .28       0  4961.3    .045       0    5036     .12       0
  5039.1     .24       0  6473.4     .99       0
Bank Sta=4961.3,5036
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,149014  ,400.4,580,376.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X42
END DESCRIPTION:
XS GIS Cut Line= 4
      3033499.66     13917577.16      3035608.76     13914000.86
      3036265.94     13913343.67        3036862.     13908789.23
#Sta/Elev= 30
   742.3   140.3  1502.8  135.96  3672.3   133.1  4157.2   127.9  4522.3   124.5
  4552.3   122.6  4592.3   113.8  4622.3   118.6  4722.3   116.6  4762.3   119.6
  4782.3   113.7  4802.3   113.4  4882.3   116.8  4904.2   117.4  4920.8  121.75
  4943.2   121.5  4970.6  118.44  5000.9  105.13  5006.3  109.07  5007.3   107.3
  5017.9  119.35  5034.8  127.45  5524.2     127  5823.6   135.5    5950   135.6
  6603.6   129.9  7303.6   135.6  7503.6   132.9  7573.6   135.9 10416.9   134.4
#Mann= 7 ,-1 , 0
   742.3     .99       0  1502.8     .28       0  4157.2     .24       0
  4882.3     .12       0  4943.2    .045       0  5034.8     .24       0
    5950     .99       0
Bank Sta=4943.2,5034.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,148434  ,642.9,569,475.8
BEGIN DESCRIPTION:
Cross Section K100-00-00-X41
END DESCRIPTION:
XS GIS Cut Line= 4
      3034065.14      13916996.4      3035715.74     13914566.34
      3036342.36     13913572.92      3036984.26     13908758.67
#Sta/Elev= 30
  1728.8   136.8  3748.8   134.2  4348.8   124.9  4608.8   126.8  4786.4   124.1
  4846.4   128.3  4928.4  122.05  4951.2  123.01  4975.2  117.64    4993  107.33
  5001.4  106.64  5008.3  106.88    5030  122.68  5059.3  126.73  5326.4   125.2
  5486.4   130.8    6120   135.8    6271   133.2    6471     136    6791   129.1
    7071   133.4    7761   132.9    7961   136.1    9671   135.3    9761     133
   10191   135.5   10341   132.8   10501   135.7   10641   132.6 10697.8   135.4
#Mann= 4 ,-1 , 0
  1728.8     .28       0  4951.2    .045       0  5059.3     .24       0
    6120     .99       0
Bank Sta=4951.2,5059.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,147865  ,1361.3,1155,844
BEGIN DESCRIPTION:
Cross Section K100-00-00-X40
END DESCRIPTION:
XS GIS Cut Line= 4
      3034386.09     13916660.16      3036128.39     13915070.69
      3036434.06     13914444.08      3037060.68     13908789.23
#Sta/Elev= 30
  2029.7   136.7  3569.7   132.8  3999.7   126.2  4718.1   124.5  4934.1  127.27
  4963.6  122.17  4984.4  114.33  4992.6   107.7  5007.5  106.88  5013.8  113.84
    5026  117.32  5083.7  117.37  5137.9   127.4  5145.3   123.6  5285.3   127.5
  5365.3   124.3  5475.3   129.6  5675.3   128.9  5815.3   133.4    6150   135.5
  6715.3   134.2  6915.3   129.9  7475.3   135.6  7635.3   132.6  7805.3   135.6
  7995.3   132.6  8605.3   136.6  9865.3   132.8 10065.3   135.4 10774.7   134.1
#Mann= 4 ,-1 , 0
  2029.7     .28       0  4934.1    .045       0  5137.9     .24       0
    6150     .99       0
Bank Sta=4934.1,5137.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,146710  ,865.2,809,902.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X39
END DESCRIPTION:
XS GIS Cut Line= 4
      3036755.01     13915697.31      3037641.45     13914505.21
      3037060.68     13913802.17       3037137.1     13908773.95
#Sta/Elev= 30
  2948.9   134.4  3198.9   134.8  3428.9   128.4  4008.9   125.7  4934.5   126.2
  4954.5   121.1  4983.5  115.34  5000.2  105.61  5027.2  115.63  5079.5  125.43
  5566.3   124.6  5666.3   128.7  5886.3   127.5  6176.3   133.6  6476.3   131.5
  6536.3   134.1  6846.3   132.2  7046.3   135.5  7596.3   135.6  7696.3   132.5
  7776.3   135.5  8236.3   135.9  8606.3   132.3  8696.3   134.7  9476.3   132.3
  9586.3   135.2 10046.3   132.2 10136.3   135.4 10326.3   132.1 10375.2   134.8
#Mann= 5 ,-1 , 0
  2948.9     .28       0  4934.5    .105       0  4954.5    .045       0
  5079.5     .24       0  6176.3     .99       0
Bank Sta=4934.5,5079.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,145901  ,979.3,1385,1306.6
BEGIN DESCRIPTION:
Cross Section XS38.5
END DESCRIPTION:
XS GIS Cut Line= 5
       3039161.6      13920314.5      3038610.66     13915406.58
      3038012.66     13913817.48      3037929.98     13913622.59
       3037195.3     13908693.47
#Sta/Elev= 30
 -1728.9   136.3  1221.1     133  3739.9     127  3799.9   124.2  3819.9   117.2
  3849.9   115.9  3889.9   127.2  3909.9   129.2  4119.9     127  4519.9     129
  4927.8   125.4  4957.8   121.7  4966.7   116.5  4983.5  114.55  5000.2  104.82
  5027.8   115.6  5057.8   122.9  5077.8   124.3  5639.5   124.9  6529.5   134.4
  7979.5   133.4  8089.5   135.8  8349.5   133.5  8489.5   135.8  9369.5   132.7
  9519.5   135.7  9659.5     132  9829.5   135.4  9979.5     132 10103.1   135.6
#Mann= 5 ,-1 , 0
 -1728.9     .99       0  1221.1     .24       0  4927.8    .045       0
  5077.8     .24       0  6529.5     .99       0
#Block Obstruct= 1 ,-1
 3736.11 3991.32  126.34
Bank Sta=4927.8,5077.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,144516  ,596,888,242.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X38
END DESCRIPTION:
XS GIS Cut Line= 4
      3039750.55     13920144.77       3039154.5     13913572.92
       3039062.8     13912854.61       3037228.8     13908651.68
#Sta/Elev= 30
 -2039.9     136   260.1   131.3  1420.1   133.9  1600.1   130.2  1890.1   134.1
    2493     132    2495   130.9  4758.9   124.6  4904.7  121.76    4968     117
  4989.8  106.44  5003.9  103.46  5034.3  118.98    5060  117.04  5128.9   121.9
  5208.9   118.7  5313.1   124.2  5463.1   124.9  5493.1   117.3  5543.1   126.3
  5613.1   131.1  5793.1   127.2  6363.1   132.8  7103.1   135.6  7903.1   132.3
  9213.1   135.3  9343.1   132.6  9533.1   135.8  9653.1   131.7  9868.7   135.1
#Mann= 6 ,-1 , 0
 -2039.9     .99       0    2493     .99       0    2495     .12       0
    4968     .06       0  5034.3     .12       0  6363.1     .99       0
#Block Obstruct= 2 ,-1
    5000  5000.1      50    5462    5534  124.92
Bank Sta=4968,5034.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,143628  ,214.8,1453,1686.1
BEGIN DESCRIPTION:
Cross Section XS37.5
END DESCRIPTION:
XS GIS Cut Line= 6
      3039792.42      13920159.3      3039776.37     13912805.96
      3039643.87     13912739.41      3039470.86     13912632.95
      3039088.52     13912442.02      3037488.98     13908529.41
#Sta/Elev= 30
 -2634.1   136.4  -964.1   131.1  -424.1   133.6  -214.1   130.1   125.9   133.3
  1395.9   131.9  1435.9   134.8  1475.9   130.5    1637     132    2317     132
    2318   127.6  3545.9   124.7  3645.9   128.3  4105.9   127.3  4405.9   122.4
  4829.3   122.2  4907.6   126.2  4967.6   117.8  5003.9  103.25  5022.8  114.52
  5380.7   114.6  5440.7   124.1  5470.7   117.9  5538.1   127.8  5638.1   129.7
  6368.1   132.3  6838.1   134.1  6878.1   130.6  7018.1   135.4    9725   132.7
#Mann= 6 ,-1 , 0
 -2634.1     .99       0    1637     .99       0    2318     .12       0
  4967.6     .06       0  5022.8     .12       0  6368.1     .99       0
Bank Sta=4967.6,5022.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,142175  ,339.5,794,761.6
BEGIN DESCRIPTION:
Cross Section K100-00-00-X37
END DESCRIPTION:
XS GIS Cut Line= 5
      3039842.25     13920144.77      3040010.37     13913160.27
      3040400.59     13912277.44      3040677.25     13911651.51
      3042165.32     13908284.88
#Sta/Elev= 30
 -3279.4   135.1 -1999.4   134.8 -1729.4   131.2 -1539.4     134 -1189.4   130.1
 -1039.4   133.4  -929.4   130.6  -469.4   133.6   590.6   131.5   710.6     138
   960.6   134.9  1000.6     130    1152     132    1817     132    1818   127.8
  3580.6   127.3  4387.1     122  4672.3   122.4  4712.3   125.3  4812.3   120.4
  4882.3     123  4942.3  120.62  4954.6  118.99  4982.3  104.22  5012.7   102.9
  5017.6  104.31  5028.1  115.63  5061.8   126.1  5936.7   132.2  9037.5     131
#Mann= 7 ,-1 , 0
 -3279.4     .99       0    1152     .99       0    1818     .12       0
  4942.3     .06       0  5061.8     .12       0  5936.7     .99       0
  9037.5     .99       0
Bank Sta=4942.3,5061.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,141381  ,271,1238,928.1
BEGIN DESCRIPTION:
Cross Section XS36.9
END DESCRIPTION:
XS GIS Cut Line= 6
       3039875.7      13920214.1      3040385.66     13913065.03
      3040817.02     13912663.81      3040938.13     13912566.92
      3041215.18     13912307.51      3042683.86     13908581.98
#Sta/Elev= 30
 -2855.6   135.3 -1025.6   133.2  -855.6   129.9  -175.6   133.5  -115.6   125.4
   -75.6   133.3   864.4   131.9   904.4   136.1  1044.4   138.4  1134.4   131.4
  1294.4   130.1  1564.4   137.2  1714.4   135.4  1744.4   129.2    1914   128.5
    1915     132    2604     132  2754.4   125.2  3304.4   127.8  4701.7   122.7
  4801.7     117  4930.8     124  4954.6  117.96  4982.3  103.19  5012.7  101.87
  5028.1   114.6  5085.9   123.9  5435.4   130.2  6175.4   131.5    9440   131.3
#Mann= 7 ,-1 , 0
 -2855.6     .99       0  1564.4     .12       0    1915     .99       0
    2604     .12       0  4930.8     .06       0  5085.9     .12       0
  6175.4     .99       0
Bank Sta=4930.8,5085.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,140143  ,781.6,539,512.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X36E
END DESCRIPTION:
XS GIS Cut Line= 4
      3039918.67      13920205.9      3040606.42     13913786.89
      3042425.14     13912503.09      3043403.27     13908926.78
#Sta/Elev= 30
 -2759.6     136 -1479.6   135.1  -749.6   129.7   -39.6     133      .4   125.5
    40.4   133.7   810.4   131.3   900.4   137.4  1290.4     138  1500.4   130.3
  1650.4   137.2  1710.4   131.3  1950.4   134.8  1980.4   127.9  2050.4   132.2
  2100.4     127    2117   128.1    2118     132    2927     132    2928   123.8
  3580.4   127.3    4943  120.61  4997.1  100.26  5014.8  101.32  5038.1  113.39
  5054.2  127.88  5084.4  121.05  5246.1   119.4  5922.3   131.6    9630   130.7
#Mann= 5 ,-1 , 0
 -2759.6     .99       0    2928     .14       0    4943     .06       0
  5054.2     .12       0  5922.3     .99       0
#Block Obstruct= 2 ,-1
  -39.48      35  132.99    2830    2978  125.61
Bank Sta=4943,5054.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,139592  ,703.73,438,461.37
BEGIN DESCRIPTION:
Interpolated for LEONE LOMR_F
END DESCRIPTION:
XS GIS Cut Line= 4
        3039939.       13920312.        3040886.       13914615.
        3042795.       13912659.        3044228.       13909380.
#Sta/Elev= 30
 -2555.3  136.13   86.03  132.65  123.66  128.14  163.72  132.97 1103.52  134.54
 1291.15  130.34 1698.02  136.86 1822.77  132.26 2018.48  134.03 2047.61  129.43
 2212.69  133.61 2659.39  128.17    3693     132    3694   125.4    3736   125.4
    3816   113.5    4142   109.1    4166     104    4536     104    4626   123.4
 4655.64  123.37 4830.71  121.25 4924.53   120.9  4997.1  101.04 5012.88  103.56
 5095.33  128.52 5125.42  124.75  5326.4  124.36 6060.06  131.91 9654.77  131.08
#Mann= 8 ,-1 , 0
 -2555.3     .99       0    3694     .04       0    4166     .01       0
    4626     .04       0 4655.64     .14       0 4924.53     .06       0
 5095.33     .12       0 6060.06     .99       0
#Block Obstruct= 1 ,-1
 3747.96 4648.76   123.5
Bank Sta=4830.71,5012.88
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,139166  ,319.8,336,332.66
BEGIN DESCRIPTION:
Cross Section XS36.8
END DESCRIPTION:
XS GIS Cut Line= 6
      3039956.24      13920398.8      3041113.28     13915288.01
      3042250.98     13913834.96      3042420.98      13913635.4
      3043095.02     13912786.44      3044898.62      13909748.4
#Sta/Elev= 30
 -2276.3   136.3   953.7   132.5  1093.7     126  1343.7   129.4  1413.7   121.7
  1663.7   136.6  2223.7   131.1  2553.7   136.8  2753.7   131.7  2803.7   137.5
  2923.7   135.1  2953.7   127.5    3096     132    3266     132    3267   124.7
    3917     104    4317     104    4412     123  4453.9   123.2  4899.3   121.3
  4952.2  118.02  4997.1   102.1  5091.5   125.4  5151.5   129.4  6111.5   131.8
  8795.5   132.9  9075.5   131.8  9145.5     126  9255.5   132.6  9688.6   131.6
#Mann= 10 ,-1 , 0
 -2276.3     .99       0  2753.7     .07       0    3096     .99       0
    3267     .04       0    3917     .01       0    4412     .04       0
  4453.9     .14       0  4899.3     .06       0  5151.5     .12       0
  6111.5     .99       0
#XS Ineff= 2 , 0
         3850.69  130.27
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
 1803.78    2800   137.1 3368.63 4483.36  123.61
Bank Sta=4899.3,5151.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,138857  ,292.2,307,303.9
BEGIN DESCRIPTION:
Interpolated for LEONE LOMR-F
END DESCRIPTION:
XS GIS Cut Line= 4
        3039978.       13920385.        3041380.       13915307.
        3042973.       13913426.        3045056.       13909859.
#Sta/Elev= 30
-2052.99  136.07 -386.74  130.95  925.44  134.69 1212.33  128.26 1454.57  130.02
 1522.39  125.93 1764.63  133.04 2393.83  129.51 2581.28  135.87 2869.22  137.27
 2977.02  135.25 3014.56  129.21 3218.23  128.12 3450.77  129.22 3528.29  124.54
    3714   123.7    3794     104    4074     104    4174   126.2 4196.86  122.21
 4899.72   122.4 4956.67  115.02 5005.49   102.6 5038.95  113.77  5131.5  125.74
 5313.67  126.17  5347.8  131.06 5587.49  128.04 6125.98  131.14 9831.56  131.09
#Mann= 8 ,-1 , 0
-2052.99     .99       0 3218.23     .04       0    3794     .01       0
    4174     .04       0 4196.86     .12       0 4899.72     .06       0
  5131.5     .12       0 6125.98     .99       0
#XS Ineff= 2 , 0
       0 4196.86  130.27               0
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
    3713 4165.02  123.73
Bank Sta=4899.72,5131.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,138523. ,100.5,103,102.7
BEGIN DESCRIPTION:
K100-00-00-S21_ELDRIDGE PKWY -US - XS4
END DESCRIPTION:
XS GIS Cut Line= 4
      3039997.09      13920372.1      3041623.63     13915325.03
      3042861.58     13914010.66      3045199.94     13909960.57
#Sta/Elev= 30
   -1776  135.79    1004  130.74    1084  139.44    1224  130.12    2414  128.83
    2494   120.7    2674  134.93    2924  138.18    3004  131.37    3454  134.93
  3616.7  123.53  3856.7  131.11  4136.7  122.52 4900.25  123.76 4974.71  106.46
 5015.89  103.23 5033.19  111.06  5106.7  121.19  5176.7  117.19  5286.7  120.26
  5332.3  131.47  5582.3  125.34  5892.3  131.64  7432.3  129.41  7622.3  133.43
  8752.3  133.54  8812.3  125.29  8872.3  131.73  8972.3  132.38 10008.9  130.45
#Mann= 5 ,-1 , 0
   -1776     .99       0    2924     .12       0 4900.25     .06       0
  5106.7     .12       0  7622.3     .99       0
#Block Obstruct= 4 ,-1
 2390.86 2754.93  128.72 3438.93 3869.19  130.95 5380.61 5799.84   130.7
  8752.3  8872.3   131.7
Bank Sta=4900.25,5106.7
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,138420  ,55.1,57,56.3
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3040034.62     13920386.93      3041685.22     13915404.56
      3042923.18     13914090.19      3045261.53      13910040.1
#Sta/Elev= 30
 -1722.7  135.48   987.3  130.98  1057.3  140.48  1117.3  132.58  1227.3  129.68
  2277.3  127.98  2897.3  137.88  3007.3  129.38  3057.3  135.08  3097.3  131.38
  3197.3  135.28  3237.3  130.18  3377.3  136.08    3526  132.68    3556  125.68
    3676  124.68  3735.8  130.05    4406  120.68  4900.4  124.15  4976.7  105.28
  5018.9  103.41  5037.5  112.41  5097.5  120.73    5196  117.48    5296  120.48
  5331.5  126.08  5561.5  124.18  5741.5  131.28  5941.5  131.58 10008.2  130.38
#Mann= 5 ,-1 , 0
 -1722.7     .99       0  3735.8     .12       0  4900.4     .06       0
  5331.5     .12       0  5941.5     .99       0
#XS Ineff= 2 , 0
       0 4866.32  129.63 5340.28       0  129.63
Permanent Ineff=
       F       F
Bank Sta=4900.4,5331.5
XS Rating Curve= 0
Exp/Cntr=.5,.3
