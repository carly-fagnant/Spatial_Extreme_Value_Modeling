HEC-RAS study K100-00-00.prj: K100-00-00

--- K100-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 3 ,98688   ,,,
BEGIN DESCRIPTION:
CHAMPIONS FOREST
Structure ID: K100-00-00-S12
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,84,2.6,0, 150, 150, , , .95, 0, ,,,
  2617.4  2677.4  2767.4  2787.4  2957.4  2977.4  3037.4  3067.4  3107.4  3167.4
  3287.4  3317.4  3437.4  3497.4  3527.4  3528.7  3547.4  3557.4  3587.4  3627.4
  3667.4  3757.4  3787.4  3797.4  3807.4  3827.4  3897.4  3997.4  4007.4  4017.4
  4027.4  4067.4  4077.4  4087.4  4097.4  4177.4  4217.4  4237.4  4267.4  4317.4
    4349  4367.4  4377.4  4377.7  4397.7  4411.4  4416.8  4478.9  4526.5  4550.7
 4566.19  4566.3 4566.41  4570.4  4591.5  4594.8  4651.3  4657.2  4715.8  4720.4
    4773  4784.9  4842.8 4843.51 4843.59    4857  4889.8  4913.5  4936.9  4945.4
  4959.3  4959.4  4964.6  4976.8  4977.5  4977.8  4981.4  4993.1  5005.3  5005.4
    5022  5022.5  5023.1  5027.4  5051.3  5073.6  5097.5  5104.6  5119.1  5143.5
  5143.6 5147.98 5148.08  5189.2  5190.3  5235.2 5250.79  5250.9 5251.01  5253.1
    5326  5326.7  5395.6  5397.9    5466    5467  5468.8    5469  5471.9  5511.9
  5531.9    5569    5579  5580.8  5671.9  5701.9  5781.9  6051.9  6081.9  6121.9
  6141.9  6161.9  6191.9  6211.9  6451.9  6471.9  6491.9  6501.9  6511.9  6581.9
  6641.9  6661.9  6681.9  6769.9  6791.9  6821.9  6851.9  6881.9  6891.9  6901.9
  6911.9  6981.9  7021.9  7041.9  7221.9  7241.9  7251.9  7261.9  7281.9  7324.1
   120.3   120.3   118.7   117.6   119.1   118.6   118.1   116.4   116.9   118.6
   117.8   118.9     120   116.7   115.8  115.73   114.7   114.5   115.4   114.2
   114.9   114.3   113.8   115.3   115.9   115.9   117.6   115.3   114.7   113.6
     113   112.7   113.3   113.3   112.8   112.1   112.4   111.3   111.5   112.5
  111.18  110.41  109.81  109.71  108.47  108.61   108.5  108.59  108.66   108.7
  108.72  110.72  110.72  110.72  110.76  110.77  110.99  111.01  111.15  111.16
  111.31  111.34  111.51  111.52  111.52  111.62  111.86  112.04  112.33  112.43
   112.6   112.5  112.57  112.74  112.74  112.75   112.8  112.96  113.12  113.03
  113.19  113.19   113.2  113.24  113.46   113.5  113.55  113.56  113.58  113.61
   113.5  113.48  113.48  113.26  113.26   113.1  113.29  113.29  111.35  111.33
  110.77  110.76   111.4  111.44  110.47  111.02  110.91  110.89  110.71  111.11
  110.61  110.66  110.68  110.68   110.8   109.6   112.1   114.2     114   113.1
   113.1   112.8   114.4   114.7   113.9   114.2   113.8   113.9   114.6   115.5
   113.6   114.6   116.2  116.36   116.4   116.7   115.6   116.6   116.4   116.7
   117.6     118   116.8     118   119.6   118.3   118.1   118.3   119.8   120.8
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                  106.92  107.02  107.26  107.44  107.73  107.83
     108   107.9  107.97  108.14  108.14  108.15   108.2  108.36  108.52  108.43
  108.59  108.59   108.6  108.64  108.86   108.9  108.95  108.96  108.98  109.01
   108.9  108.88
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
  2617.4  2677.4  2767.4  2787.4  2957.4  2977.4  3037.4  3067.4  3107.4  3167.4
  3287.4  3317.4  3437.4  3497.4  3527.4  3528.7  3547.4  3557.4  3587.4  3627.4
  3667.4  3757.4  3787.4  3797.4  3807.4  3827.4  3897.4  3997.4  4007.4  4017.4
  4027.4  4067.4  4077.4  4087.4  4097.4  4177.4  4217.4  4237.4  4267.4  4317.4
    4349  4367.4  4377.4  4377.7  4397.7  4411.4  4416.8  4478.9  4526.5  4550.7
 4566.19  4566.3 4566.41  4570.4  4591.5  4594.8  4651.3  4657.2  4715.8  4720.4
    4773  4784.9  4842.8 4843.51 4843.59    4857  4889.8  4913.5  4936.9  4945.4
  4959.3  4959.4  4964.6  4976.8  4977.5  4977.8  4981.4  4993.1  5005.3  5005.4
    5022  5022.5  5023.1  5027.4  5051.3  5073.6  5097.5  5104.6  5119.1  5143.5
  5143.6 5147.98 5148.08  5189.2  5190.3  5235.2 5250.79  5250.9 5251.01  5253.1
    5326  5326.7  5395.6  5397.9    5466    5467  5468.8    5469  5471.9  5511.9
  5531.9    5569    5579  5580.8  5671.9  5701.9  5781.9  6051.9  6081.9  6121.9
  6141.9  6161.9  6191.9  6211.9  6451.9  6471.9  6491.9  6501.9  6511.9  6581.9
  6641.9  6661.9  6681.9  6769.9  6791.9  6821.9  6851.9  6881.9  6891.9  6901.9
  6911.9  6981.9  7021.9  7041.9  7221.9  7241.9  7251.9  7261.9  7281.9  7324.1
   120.3   120.3   118.7   117.6   119.1   118.6   118.1   116.4   116.9   118.6
   117.8   118.9     120   116.7   115.8  115.73   114.7   114.5   115.4   114.2
   114.9   114.3   113.8   115.3   115.9   115.9   117.6   115.3   114.7   113.6
     113   112.7   113.3   113.3   112.8   112.1   112.4   111.3   111.5   112.5
  111.18  110.41  109.81  109.71  108.47  108.61   108.5  108.59  108.66   108.7
  108.72  110.72  110.72  110.72  110.76  110.77  110.99  111.01  111.15  111.16
  111.31  111.34  111.51  111.52  111.52  111.62  111.86  112.04  112.33  112.43
   112.6   112.5  112.57  112.74  112.74  112.75   112.8  112.96  113.12  113.03
  113.19  113.19   113.2  113.24  113.46   113.5  113.55  113.56  113.58  113.61
   113.5  113.48  113.48  113.26  113.26   113.1  113.29  113.29  111.35  111.33
  110.77  110.76   111.4  111.44  110.47  111.02  110.91  110.89  110.71  111.11
  110.61  110.66  110.68  110.68   110.8   109.6   112.1   114.2     114   113.1
   113.1   112.8   114.4   114.7   113.9   114.2   113.8   113.9   114.6   115.5
   113.6   114.6   116.2  116.36   116.4   116.7   115.6   116.6   116.4   116.7
   117.6     118   116.8     118   119.6   118.3   118.1   118.3   119.8   120.8
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                  106.92  107.02  107.26  107.44  107.73  107.83
     108   107.9  107.97  108.14  108.14  108.15   108.2  108.36  108.52  108.43
  108.59  108.59   108.6  108.64  108.86   108.9  108.95  108.96  108.98  109.01
   108.9  108.88
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4889.8, 2 ,4889.8, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   101.1  108.27
     1.5     1.5
   101.1  108.27
Pier Skew, UpSta & Num, DnSta & Num=  ,4936.9, 2 ,4936.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   97.42  108.74
     1.5     1.5
   97.42  108.74
Pier Skew, UpSta & Num, DnSta & Num=  ,4981.4, 2 ,4981.4, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   83.44  109.21
     1.5     1.5
   83.44  109.21
Pier Skew, UpSta & Num, DnSta & Num=  ,5027.4, 2 ,5027.4, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   88.61  109.65
     1.5     1.5
   88.61  109.65
Pier Skew, UpSta & Num, DnSta & Num=  ,5073.6, 2 ,5073.6, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   99.93   109.9
     1.5     1.5
   99.93   109.9
Pier Skew, UpSta & Num, DnSta & Num=  ,5119.1, 2 ,5119.1, 2 , 0 , 0 , 0 ,,
     1.5     1.5
  105.05  109.98
     1.5     1.5
  105.05  109.98
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=120.8

Type RM Length L Ch R = 1 ,98634   ,297.8,261,244.5
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
       3064504.2     13927665.36      3066223.52     13927252.72
       3066523.1      13926806.9      3066658.41     13926590.66
      3067871.09     13924800.98
#Sta/Elev= 30
  2617.4   120.3  2787.4   117.6  2957.4   119.1  3067.4   116.4  3437.4     120
  3557.4   114.5  3787.4   113.8  3897.4   117.6  4027.4     113  4317.4   112.5
  4526.5  104.13    4857  103.85  4945.4   96.86  4964.6   88.02  4976.8   86.34
  4981.4   82.76  4993.1   82.33    5022   84.94  5027.4   88.42  5073.6    99.4
  5189.2  110.11  5190.3  111.91  5701.9   109.6  6051.9   114.2  6161.9   112.8
  6581.9   115.5  6641.9   113.6  6681.9   116.2  7251.9   118.1  7324.1   120.8
#Mann= 5 ,-1 , 0
  2617.4     .99       0  3897.4      .1       0    4857     .06       0
  5190.3      .1       0  6051.9     .99       0
#XS Ineff= 2 , 0
       0  4833.5  108.78  5158.3       0  110.76
Permanent Ineff=
       F       F
Bank Sta=4857,5190.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,98373   ,665.4,1086,1110.8
BEGIN DESCRIPTION:
Cross Section XS30.2
END DESCRIPTION:
XS GIS Cut Line= 5
      3064553.92      13927682.8      3066434.03     13927482.38
       3066797.2     13926865.97       3066835.7     13926774.53
      3068007.47     13924870.41
#Sta/Elev= 30
    2345   119.2    2715   115.6    3075   118.8    3195   115.2    3505   114.5
    3855   106.9    3925   111.6    4035   106.4    4215     104  4315.8   107.5
  4455.8     106  4525.8   110.6  4625.8   107.7  4665.8   111.2  4845.8   105.8
  4885.8   100.6  4935.8   101.8  4961.2    96.8  4981.4   83.47  4993.1   83.04
    5022   85.65  5050.4   103.2  5130.4    95.2  5220.4     100  5280.4   107.1
  5630.4     112  5810.4   110.5  6220.4   115.7  6590.4   114.1  7286.2   120.6
#Mann= 7 ,-1 , 0
    2345     .99       0    3505      .1       0    4215     .12       0
  4935.8     .06       0  5050.4     .12       0  5630.4      .1       0
  6220.4     .99       0
Bank Sta=4935.8,5050.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,97287   ,1073.9,744,697.4
BEGIN DESCRIPTION:
Cross Section K100-00-00-X30A
END DESCRIPTION:
XS GIS Cut Line= 5
      3064598.53     13927702.39      3066994.96     13927770.86
      3067425.34     13927702.39      3067728.56     13927389.38
      3068726.26     13925257.05
#Sta/Elev= 30
  2001.7   120.7  2281.7     116  2331.7   119.5  2481.7   116.3  2751.7   118.4
  3341.7   110.4  3401.7   114.9  3851.7   114.7  4131.7   106.8  4331.7   107.1
  4371.7   111.6  4449.1   104.3  4549.1   108.5  4699.1   112.1  4879.7  103.21
  4900.6   98.57  4952.4   99.17  4981.7   86.72  5010.3   86.16  5019.1   86.71
  5036.6   99.71  5144.9    93.9  5184.9    96.1  5234.9   105.5  5270.7   105.2
  5640.7   111.1  6520.7   114.2  6940.7   122.4  7520.7   121.9  7624.9   124.2
#Mann= 7 ,-1 , 0
  2001.7     .99       0  3851.7      .1       0  4549.1     .12       0
  4952.4     .06       0  5036.6     .12       0  5270.7      .1       0
  5640.7     .99       0
#XS Ineff= 2 , 0
         3851.56  114.61
Permanent Ineff=
       F       F
Bank Sta=4952.4,5036.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,96543   ,840.2,1018,895.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X30
END DESCRIPTION:
XS GIS Cut Line= 4
       3066639.9      13930068.1      3068027.04     13928144.39
      3068150.05     13927973.79      3068824.66     13927038.23
#Sta/Elev= 30
  2523.9   115.5  2793.9   117.9  2933.9   113.2  3113.9   114.5  3253.9   109.7
  3303.9   112.5  3463.9     112  3533.9   108.6  3593.9   112.6  3703.9   107.3
  3923.9   112.6  4013.9   112.1  4103.9   107.2  4193.9   110.6  4613.9   110.1
  4703.9   108.3  4848.3   96.18  4919.5   97.97  4953.1   94.78  4984.6   84.82
  5002.5   83.62  5015.5   84.84  5025.7   94.58  5167.8  105.27  5235.9   102.6
  5345.9   104.1  5445.9   112.9  5605.9   107.4  5805.9   114.2  6259.3   116.4
#Mann= 5 ,-1 , 0
  2523.9     .99       0  3593.9      .1       0  4953.1     .06       0
  5025.7      .1       0  5445.9     .99       0
#XS Ineff= 2 , 0
         3117.19  114.43
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
    5452    5809   112.9    5810    5811     100
Bank Sta=4953.1,5025.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,95525   ,714,1080,1215.5
BEGIN DESCRIPTION:
Cross Section XS29.5
END DESCRIPTION:
XS GIS Cut Line= 5
      3066941.05      13930512.6      3068922.97     13928561.51
      3068969.19     13928410.14      3069029.44     13928239.43
      3069388.74     13927215.37
#Sta/Elev= 30
  1941.2   120.7  2421.2   113.7  2841.2   111.8  3411.2   107.4  3551.2   110.2
  3891.2     106  4041.2   108.3  4131.2   114.3  4361.2   114.7  4381.2   111.5
  4471.2   111.2  4491.2   114.9  4541.2   112.9  4591.2   104.5  4711.2   104.5
  4822.3    96.6  4862.3    95.4  4940.6    99.6  4950.6    98.6  4953.1   94.05
  4984.6   84.09  5002.5   82.89  5050.6    94.8  5121.6   107.4  5201.6   107.6
  5341.6   114.9  5641.6   119.2  5851.6   115.2  6091.6   115.6  6146.9   119.4
#Mann= 7 ,-1 , 0
  1941.2     .99       0  2841.2      .1       0  3411.2     .12       0
  4940.6     .06       0  5121.6     .12       0  5341.6      .1       0
  5641.6     .99       0
Bank Sta=4940.6,5121.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,94445   ,1073.5,782,489.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X29
END DESCRIPTION:
XS GIS Cut Line= 3
      3067171.24     13930691.66      3070204.87     13928800.75
      3070642.03     13928099.84
#Sta/Elev= 30
  2120.3   120.8  2570.3   114.4  2640.3     116  2870.3   111.9  3100.3     112
  3380.3   106.2  3450.3     108  3470.3   105.9  3830.3   108.4  4510.1  107.82
  4650.3   107.3  4680.3   103.9  4906.8  103.44  4958.7   95.52  4982.4   83.42
  4999.7   82.12  5017.9    83.6  5037.2   97.39  5092.1   92.67  5140.3   103.2
  5250.3   104.7  5320.3   101.8  5360.3   103.8  5380.3   102.3  5420.3   105.8
  5500.3   107.8  5680.3   107.3    5855     113    6165   115.4  6521.1   122.3
#Mann= 5 ,-1 , 0
  2120.3     .99       0  3100.3      .1       0  4510.1     .12       0
  4958.7     .06       0  5037.2     .12       0
Bank Sta=4958.7,5037.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,93663   ,1307.6,1940,1822.4
BEGIN DESCRIPTION:
Cross Section XS29.1
END DESCRIPTION:
XS GIS Cut Line= 5
      3068120.81      13932075.4      3070018.31     13929849.05
      3070037.73     13929679.08      3070043.49     13929596.26
      3070949.34       13928238.
#Sta/Elev= 30
  1965.9   123.6  2095.9   121.1  2195.9   123.3  2385.9   118.5  2495.9   118.4
  2665.9   112.5  3035.9   106.2  3285.9   105.6  3375.9   108.2  3575.9   109.6
  4585.9     110  4675.9     112  4795.9   109.3  4855.9   102.5  4911.2   105.5
  4941.2   102.6  4982.4   83.17  4999.7   81.87  5017.9   83.35  5051.2    92.7
  5092.3    99.2  5185.3   105.1  5295.3     100  5345.3    99.6  5455.3   103.3
  5525.3   107.9  5855.3   111.1  6045.3   115.7  6355.3   115.3  6777.9   122.3
#Mann= 5 ,-1 , 0
  1965.9     .99       0  2495.9      .1       0  4795.9     .12       0
  4911.2     .06       0  5185.3      .1       0
Bank Sta=4911.2,5185.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,91723   ,799.2,646,596.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X29A
END DESCRIPTION:
XS GIS Cut Line= 2
      3069132.01     13932735.07      3072602.79     13928370.29
#Sta/Elev= 30
     722   119.2    1672   104.6    1792   108.3    2342   105.6    2762   108.4
    2912   107.3    2982   104.5    3012   108.2    3342   110.1    3682   107.9
    3852   109.2    3892   111.3    3942   109.7    4122     111    4372     108
    4582   108.1  4944.7   94.78  4980.7   82.78  4999.7   81.24  5021.5   82.34
    5054  100.67  5082.4  103.42  5123.5  104.15    5168  114.21  5185.8  114.53
    5542   118.6    5822   117.8    6092   121.4    6132   119.7  6298.5   122.6
#Mann= 4 ,-1 , 0
     722      .1       0    3892     .12       0  4944.7     .06       0
    5054      .1       0
Bank Sta=4944.7,5054
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,91077   ,205.3,208,176
BEGIN DESCRIPTION:
Cross Section XS28.7
END DESCRIPTION:
XS GIS Cut Line= 5
      3069872.89      13933206.7      3072153.61     13929845.06
      3072236.88     13929770.12      3072381.83     13929615.63
      3073146.13     13928492.22
#Sta/Elev= 30
   865.1     116   995.1   117.4  1535.1   112.4  1655.1   114.4  1695.1   112.1
  2045.1   112.4  2415.1   105.8  2905.1   105.9  2955.1   111.2  3065.1   109.8
  3135.1   106.4  3495.1   102.8  3875.1   105.7  4185.1   102.4  4245.1   105.2
  4505.1   100.6  4775.1   107.3  4905.1   102.9  4947.4    97.5  4951.3   91.69
  4979.8   82.36    5000   80.39  5020.1   81.87  5031.2   90.12  5099.4   103.1
  5159.4   106.5  5261.3   119.2  5411.3   122.2  5681.3   125.4    6610     123
#Mann= 4 ,-1 , 0
   865.1     .99       0  2045.1     .12       0  4905.1     .06       0
  5099.4     .12       0
#XS Ineff= 2 , 0
         3335.94  110.67
Permanent Ineff=
       F       F
Bank Sta=4905.1,5099.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,90869   ,97.3,104,112.6
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 2
      3070066.85     13933289.76      3073217.14     13928599.26
#Sta/Elev= 30
 810.699  116.611578.496  114.41  2195.9  106.012440.487  110.782575.841  108.81
2662.911  103.812813.304  103.412820.587  109.65 3008.42  109.333065.569   93.01
3065.886   96.653080.926   93.683127.547   98.613162.217  109.423169.578  111.71
3782.866  114.433826.401  104.223921.149   91.043941.729   82.033957.718   80.06
3973.628   81.543984.394   90.973999.037   94.944119.431  111.444133.204   114.5
4282.093  114.764285.576  120.514578.447  125.915195.851  125.215283.079  122.51
#Mann= 6 ,-1 , 0
 810.699     .99       02440.487     .12       0 3008.42     .06       0
3162.217     .12       03782.866     .06       04119.431     .12       0
#XS Ineff= 2 , 0
       0    3000  110.454119.431       0   115.2
Permanent Ineff=
       F       F
Bank Sta=3782.866,4119.431
XS Rating Curve= 0
Skew Angle= 37.67
Exp/Cntr=.5,.3

Type RM Length L Ch R = 4 ,90822.5 ,,,
BEGIN DESCRIPTION:
STUEBNER-AIRLINE
Structure ID: K100-00-00-S11
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,73,2.6,37.67, 60, 60, , , .95, 0, ,,,
 810.699 905.684 961.092  1016.51261.8791301.4561388.5261404.3571578.4961633.904
1847.6211974.268 2005.932061.3382124.6612172.154  2195.92251.3082306.717 2370.04
2393.7862433.3642472.9412496.6872552.0952575.8412591.6722623.3342662.911 2734.15
2813.3042820.5872869.7342869.8213002.325 3008.423162.1773169.5783201.7153271.925
3782.8663792.6814108.9824110.4794110.5654119.8264119.9144133.2044239.4294282.093
4282.3314285.5764578.447 4728.844839.6564982.1345037.5425085.0355195.8515283.079
   116.6     117   115.7   116.2     115   116.1   115.7   114.5   114.4   112.1
     111   108.8   106.7   108.5   108.7   107.9     106   105.9   108.5   107.8
   110.5     111   109.7   109.9   109.8   109.8   109.8   109.8   109.8  110.06
  110.78  110.85  111.29  114.09  114.61  114.77  115.12  115.07  114.66  114.76
   118.3  118.42  118.12  118.11  118.11  118.03  115.23  115.05  115.76  115.62
  116.76  120.51   125.9   125.7   124.2   124.8   123.3   125.4   125.2   122.5
   116.6     117   115.7   116.2     115   116.1   115.7   114.5   114.4   112.1
     111   108.8   106.7   108.5   108.7   107.9     106   105.9   108.5   107.8
   110.5     111   109.7   109.9   108.2   108.8   108.3   105.2   103.8   104.7
   103.4  109.64  110.16  110.16  111.06  109.32  109.39   111.7  110.21  108.81
  114.42  112.22  111.92  111.91  110.13  111.52  111.54  114.49  115.75  114.75
  116.75   120.5   125.9   125.7   124.2   124.8   123.3   125.4   125.2   122.5
 810.699 905.684 961.092  1016.51261.8791301.4561388.5261404.3571578.4961633.904
1847.6211974.268 2005.932061.3382124.6612172.154  2195.92251.3082306.717 2370.04
2393.7862433.3642472.9412496.6872552.0952575.8412591.6722623.3342662.911 2734.15
2813.3042820.5872869.7342869.8213002.325 3008.423162.1773169.5783201.7153271.925
3782.8663792.6814108.9824110.4794110.5654119.8264119.9144133.2044239.4294282.093
4282.3314285.5764578.447 4728.844839.6564982.1345037.5425085.0355195.8515283.079
   116.6     117   115.7   116.2     115   116.1   115.7   114.5   114.4   112.1
     111   108.8   106.7   108.5   108.7   107.9     106   105.9   108.5   107.8
   110.5     111   109.7   109.9   109.8   109.8   109.8   109.8   109.8  110.06
  110.78  110.85  111.29  114.09  114.61  114.77  115.12  115.07  114.66  114.76
   118.3  118.42  118.12  118.11  118.11  118.03  115.23  115.05  115.76  115.62
  116.76  120.51   125.9   125.7   124.2   124.8   123.3   125.4   125.2   122.5
   116.6     117   115.7   116.2     115   116.1   115.7   114.5   114.4   112.1
     111   108.8   106.7   108.5   108.7   107.9     106   105.9   108.5   107.8
   110.5     111   109.7   109.9   108.2   108.8   108.3   105.2   103.8   104.7
   103.4  109.64  110.16  110.16  111.06  109.32  109.39   111.7  110.21  108.81
  114.42  112.22  111.92  111.91  110.13  111.52  111.54  114.49  115.75  114.75
  116.75   120.5   125.9   125.7   124.2   124.8   123.3   125.4   125.2   122.5
Pier Skew, UpSta & Num, DnSta & Num=  ,3073.881, 2 ,3073.881, 2 , 0 , 0 , 0 ,,
     1.3     1.3
   93.36  110.65
     1.3     1.3
   94.31   111.6
Pier Skew, UpSta & Num, DnSta & Num=  ,3113.774, 2 ,3113.774, 2 , 0 , 0 , 0 ,,
     1.3     1.3
   96.62   110.7
     1.3     1.3
   97.57  111.65
Pier Skew, UpSta & Num, DnSta & Num=  ,3858.221, 2 ,3858.221, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   99.99  113.45
     1.4     1.4
  100.94   114.4
Pier Skew, UpSta & Num, DnSta & Num=  ,3921.149, 2 ,3921.149, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   89.83  113.57
     1.4     1.4
   90.78  114.52
Pier Skew, UpSta & Num, DnSta & Num=  ,3984.394, 2 ,3984.394, 2 , 0 , 0 , 0 ,,
     1.4     1.4
   89.63  113.48
     1.4     1.4
   90.58  114.43
Pier Skew, UpSta & Num, DnSta & Num=  ,4048.825, 2 ,4048.825, 2 , 0 , 0 , 0 ,,
     1.4     1.4
  100.47  113.26
     1.4     1.4
  101.42  114.21
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Mult= 3 ,810.699,3555.77,810.699,3555.77
BC Mult= 3 ,3351.4,5283.079,3351.4,5283.079
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=125.91

Type RM Length L Ch R = 1 ,90765   ,157.8,214,235
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 2
      3070124.31      13933372.4      3073274.59     13928681.89
#Sta/Elev= 30
 810.699  117.551578.496  115.35  2195.9  106.952440.487  111.722575.841  109.75
2662.911  104.752813.304  104.352820.587  110.59 3008.42  110.273065.569   93.95
3065.886   97.593080.926   94.623127.547   99.553162.217  110.363169.578  112.65
3782.866  115.373826.401  105.163921.149   91.983941.729   82.973957.718      81
3973.628   82.483984.394   91.913999.037   95.884119.431  112.384133.204  115.44
4282.093   115.74285.576  121.454578.447  126.855195.851  126.155283.079  123.45
#Mann= 6 ,-1 , 0
 810.699     .99       02440.487     .12       0 3008.42     .06       0
3162.217     .12       03782.866    .042       04119.431     .12       0
#XS Ineff= 2 , 0
       0 2994.14  110.224119.431       0   115.2
Permanent Ineff=
       F       F
Bank Sta=3782.866,4119.431
XS Rating Curve= 0
Skew Angle= 37.67
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,90551   ,544.3,766,749.3
BEGIN DESCRIPTION:
Cross Section XS28.3
END DESCRIPTION:
XS GIS Cut Line= 5
      3070240.81      13933475.8      3072347.55     13930333.34
       3072458.5      13930248.8      3072547.44     13930113.29
       3073252.9     13929006.19
#Sta/Elev= 30
  1118.3   116.1  2358.3     113  2708.3   110.8  2798.3   107.2  3448.3   107.5
  3688.3     109  3838.3   103.2  4058.3   100.6  4108.3    94.5  4168.3   102.5
  4418.3   105.6  4548.3   100.1  4638.3   103.4  4748.3     102  4798.3    96.9
  4878.3   101.1  4948.3   96.38  4973.8   90.08  4980.5   81.55  4994.3   80.92
  5022.6    82.1  5071.1   102.9  5111.1   106.3  5513.2   116.5  5793.2   120.1
  6073.2   119.9  6223.2   123.7  6283.2   118.8  6373.2   123.7    6516   120.3
#Mann= 5 ,-1 , 0
  1118.3     .99       0  2358.3      .1       0  3448.3     .14       0
  4878.3    .042       0  5111.1     .14       0
#XS Ineff= 2 , 0
         3689.45  110.22
Permanent Ineff=
       F       F
Bank Sta=4878.3,5111.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,89785   ,1099.7,1077,690.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X28A
END DESCRIPTION:
XS GIS Cut Line= 4
      3071017.28     13933285.55      3072516.97     13931040.49
      3072835.99     13930956.83      3073705.65     13929762.11
#Sta/Elev= 30
  2165.2   115.7  2365.2     113  3035.2   113.3  3435.2   109.1  3595.2     110
  3705.2   104.4  3885.2   107.4  4065.2   101.8  4335.2   104.9  4475.2   100.5
  4735.2   104.5  4876.4  103.88  4906.7  106.37  4921.2   97.19  4948.3   96.06
  4973.8   89.76  4980.5   81.23  4994.3    80.6  5044.9   83.36  5079.6    99.7
  5214.9   103.6  5384.9   102.8  5604.9   109.4  5844.9   105.1  5984.9   109.5
  6094.9   116.9  6174.9     114  6454.9     117  6514.9     120  6672.6   120.1
#Mann= 4 ,-1 , 0
  2165.2     .99       0  3595.2     .14       0  4906.7    .042       0
  5079.6     .14       0
Bank Sta=4906.7,5079.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,88708   ,803.8,1105,1196
BEGIN DESCRIPTION:
Cross Section XS28.1
END DESCRIPTION:
XS GIS Cut Line= 5
      3071833.77      13933828.6      3073483.11     13931521.32
      3073566.09     13931191.06      3073604.43     13931037.73
      3074098.83     13929934.93
#Sta/Elev= 30
  1751.9   111.1  1891.9   109.2  1981.9   111.9  2271.9   110.1  2361.9   111.9
  3291.9   110.2  3441.9     108  3701.9   111.2  3891.9   109.7  3951.9   107.3
  4708.1     105  4768.1   108.1  4848.1    98.5  4938.7    98.3  4973.8    89.6
  4980.5   81.07  4994.3   80.44  5044.9    83.2  5048.7    99.3  5058.7   102.4
  5156.7   100.2  5366.7   105.5  5466.7   105.6  5566.7   104.2  5626.7    97.3
  5706.7    98.3  5896.7   116.8  5976.7   121.3  6016.7   120.2  6295.3   124.5
#Mann= 5 ,-1 , 0
  1751.9     .99       0  1891.9      .1       0  4708.1     .06       0
  4768.1    .042       0  5058.7     .14       0
#XS Ineff= 2 , 0
         2781.25  111.12
Permanent Ineff=
       F       F
Bank Sta=4768.1,5058.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,87603   ,392.3,1128,944.5
BEGIN DESCRIPTION:
Cross Section K100-00-00-X28
END DESCRIPTION:
XS GIS Cut Line= 4
      3072640.54     13933771.66       3074595.2      13931276.3
      3074734.16     13930965.74      3075223.87     13929948.74
#Sta/Elev= 30
    1662   114.6  1882.1     110  2392.1   111.7  2502.1   106.2  2582.1     110
  2802.1   106.2  3099.5  108.89  3282.1   103.5  3502.1   106.6  3882.1     102
  4152.1   107.7  4923.7  103.55  4960.4   95.62  4983.8   81.11  4999.1   80.28
  5018.1   81.03  5059.8   99.36  5082.4  101.19  5104.1  109.94  5212.1   101.4
  5252.1    93.4  5502.1    93.3  5682.1    96.9  5782.1   106.1  5802.1   111.7
  5962.1   114.9  6032.1   125.6  6112.1   125.4  6152.1   119.3  6300.9   119.3
#Mann= 4 ,-1 , 0
    1662     .99       0  3099.5      .1       0  4923.7    .042       0
  5059.8     .12       0
#XS Ineff= 2 , 0
         2593.75  110.34
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
  5104.1 5803.02   109.9    5804    5805     100
Bank Sta=4923.7,5059.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,86475   ,938.1,1330,761.6
BEGIN DESCRIPTION:
Cross Section XS27.1
END DESCRIPTION:
XS GIS Cut Line= 4
      3072645.22      13933935.5      3075566.81     13930897.57
      3075655.76     13930808.62       3076497.4     13929953.39
#Sta/Elev= 30
   715.6   113.7  1375.6   109.1  1455.6   112.8  1635.6   111.4  1685.6     107
  1765.6   110.7  1975.6   106.8  2295.6   108.9  2515.6     104  2955.6   105.7
  3015.6   102.6  3075.6   106.8  3365.6   107.1  3755.6   104.6  4225.6   109.3
  4615.6    99.9  4725.6   104.1  4855.6      99  4905.6   101.7  4983.8   78.78
  4999.1   77.95  5018.1    78.7  5020.5    82.6  5076.3     102  5206.3     108
  5326.3   108.3  5436.3   101.1  5716.3   106.6  6146.3   122.3  6256.2   120.5
#Mann= 4 ,-1 , 0
   715.6     .99       0  2515.6      .1       0  4905.6    .042       0
  5076.3     .14       0
#XS Ineff= 2 , 0
         1770.51  110.58
Permanent Ineff=
       F       F
Bank Sta=4905.6,5076.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,85145   ,392.6,1595,1557
BEGIN DESCRIPTION:
Cross Section K100-00-00-X27A
END DESCRIPTION:
XS GIS Cut Line= 4
      3072681.98     13934005.15      3075716.89     13932195.89
      3075831.53     13931891.47      3076885.33     13930299.43
#Sta/Elev= 30
    1279   114.3    1909   109.5    2189   111.8    2639     108    2689   105.3
    3019   107.1    3409   104.5    3499   107.5    3599   105.4    3969   107.9
    4689   107.2  4841.4  102.04  4898.5  104.85  4956.2   92.67    4983   77.44
  5006.7    75.2  5016.7   77.75  5055.9   99.73  5089.3   98.46  5137.6   102.5
  5357.6    98.5  5437.6   105.1  5657.6    99.1  5717.6   102.7  6097.6   102.2
  6257.6   107.8  6407.6   108.9  6817.6   112.3  6887.6   115.7  7046.8   114.9
#Mann= 5 ,-1 , 0
    1279     .99       0    3599      .1       0  4898.5    .042       0
  5055.9     .14       0  6407.6     .99       0
Bank Sta=4898.5,5055.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,83550   ,2325.7,1227,899.3
BEGIN DESCRIPTION:
Cross Section K100-00-00-X27
END DESCRIPTION:
XS GIS Cut Line= 5
      3072745.15     13934035.71      3076431.25     13932329.49
      3076857.14     13932641.74       3077292.2     13932421.17
      3078092.37     13931483.62
#Sta/Elev= 30
   221.5   113.9   681.5   108.8  1141.5   111.7  1231.5   106.9  1301.5   112.6
  1761.5   105.1  2171.5   107.9  2481.5     105  2621.5   109.1  2941.5   107.9
  3041.5   103.8  3081.5   106.2  3121.5   102.5  3281.5   106.3  3491.5   102.2
  3731.5   106.2  4633.3   107.1  4703.3   101.5  4937.8  101.33  4951.3   92.16
  4965.3   89.71  4981.6   76.67  4996.6   76.56  5020.5   78.27  5059.9   97.61
    5319  106.69  5759.2   109.2  6099.2     116  6419.2   115.1  6531.8   118.6
#Mann= 5 ,-1 , 0
   221.5     .99       0  2621.5      .1       0  4937.8    .042       0
  5059.9     .14       0    5319     .99       0
#XS Ineff= 2 , 0
         1305.66  111.91
Permanent Ineff=
       F       F
Bank Sta=4937.8,5059.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,82323   ,1040.2,1873,1345.5
BEGIN DESCRIPTION:
Cross Section XS26.5
END DESCRIPTION:
XS GIS Cut Line= 5
      3076015.14      13935911.1      3077437.55     13933949.04
      3077540.51     13933714.79      3077595.97     13933563.55
      3078688.11     13931822.18
#Sta/Elev= 30
  2222.8     112  2352.8   114.2  3012.8   106.9  3232.8   109.8  3322.8     108
  3432.8   101.6  3502.8   103.9  3612.8   101.4  3892.8   101.2  4462.8   105.7
  4646.3     104  4866.3    97.4  4912.2    93.8  4932.2    88.6  4952.2      80
  4996.6   75.83  5020.5   77.54  5042.3   89.65  5083.2    97.5  5143.2    96.7
  5233.2   103.5  5273.2   103.9  5323.2    97.9  5593.2   106.7  6103.2   102.6
  6243.2   106.2  6353.2   104.7  6563.2     109  6883.2   111.2  7118.8   117.3
#Mann= 4 ,-1 , 0
  2222.8     .14       0  4866.3    .042       0  5083.2     .14       0
  5273.2      .1       0
#XS Ineff= 2 , 0
         3160.16  110.11 6382.81           110.9
Permanent Ineff=
       F       F
Bank Sta=4866.3,5083.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,80450   ,1384.2,1495,1237.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-XS26B
END DESCRIPTION:
XS GIS Cut Line= 4
      3077006.22     13936004.16      3078694.92       13934074.
      3079042.01     13934007.44      3079161.69     13932196.15
#Sta/Elev= 30
  2294.8   114.5  2624.8   111.2  2695.3  106.61  2764.8   107.8  3114.8   102.5
  3674.8    98.6  4074.8   102.9  4454.8      97  4674.8    98.3  4814.8    94.8
  4879.4    98.7  4909.4      96  4919.4    96.9  4920.1   99.82    4931  100.07
  4996.4   77.38  5016.4   74.72  5038.6   77.72  5055.3   86.14    5069  101.85
  5292.8   107.2  5532.8   103.7  5982.8   103.4  6212.8   106.5  6302.8   104.5
  6362.8     109  6862.8   114.1  6912.8   112.1  6952.8   115.4  7028.1   116.4
#Mann= 5 ,-1 , 0
  2294.8     .99       0  2695.3     .14       0    4931    .042       0
    5069     .12       0  5292.8      .1       0
Bank Sta=4931,5069
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,78955   ,461.6,777,477.2
BEGIN DESCRIPTION:
Cross Section K100-00-00-X26
END DESCRIPTION:
XS GIS Cut Line= 4
      3078071.77     13936738.19      3079277.16     13935526.16
      3079639.87      13934864.5      3080425.92     13932312.17
#Sta/Elev= 30
  2925.4   110.4  3770.9  111.94  3825.4   111.4  4025.4     100  4225.4    96.5
  4385.4   101.5  4495.4    98.4  4809.6    96.2  4916.3   99.78  4940.8    91.1
  4967.2    77.5  4994.4   73.72  5033.2   75.97  5034.1   78.59  5052.6   84.41
  5064.2   92.49  5140.1   98.58  5144.8    95.9  5184.8    96.5  5224.8   101.4
  5304.8   104.3  5619.3     103  5659.3    99.2  5899.3    98.3  5999.3   104.4
  6229.3   101.8  6337.8  104.64  6949.3   104.4  7089.3   107.9    8060   114.7
#Mann= 6 ,-1 , 0
  2925.4     .99       0  3770.9     .14       0  4916.3    .042       0
  5064.2     .06       0  6337.8     .12       0  6949.3     .99       0
#Block Obstruct= 1 ,-1
 5585.03 6095.24  102.25
Bank Sta=4916.3,5064.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,78178   ,1677.9,1604,237
BEGIN DESCRIPTION:
Cross Section XS26.2
END DESCRIPTION:
XS GIS Cut Line= 5
      3078364.45      13937040.1      3079676.48     13935790.19
      3079779.69     13935690.43      3080068.01      13935370.4
       3080453.7     13932290.09
#Sta/Elev= 30
  3112.3   115.8  3452.3   113.2  3862.3   116.5  4102.3   111.1  4342.3    97.8
  4592.3    95.7  4882.3   100.7  4934.4    94.9  4967.2   77.24  4994.4   73.46
  5033.2   75.71  5052.6   84.15  5064.4    94.1    5168   105.8    5238   105.6
    5298    94.8    5358    91.3    5418    93.5    5478   105.1  5638.7   103.5
  5698.7    98.8  5948.7   101.9  6128.7    98.4  6318.7   107.7  6378.7   107.2
  6548.7    99.4  6728.7   103.7  7028.7     102  7458.7   106.3  8603.1   114.8
#Mann= 6 ,-1 , 0
  3112.3     .99       0  4102.3     .14       0  4882.3    .042       0
    5168     .06       0  6378.7     .12       0  7458.7     .99       0
#XS Ineff= 2 , 0
                         7453.12          106.18
Permanent Ineff=
       F       F
#Block Obstruct= 2 ,-1
 5243.42 5479.56  104.81  5638.8    6169  102.29
Bank Sta=4882.3,5168
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,76574   ,539.1,1284,177.3
BEGIN DESCRIPTION:
Cross Section XS26.1
END DESCRIPTION:
XS GIS Cut Line= 5
      3080881.52      13937450.1      3080724.49     13936910.08
      3080695.11     13936835.84      3080340.13     13935512.12
       3080473.9     13932293.46
#Sta/Elev= 30
  4284.3   115.8  4916.7    96.5  4935.6   83.17  4956.7   82.56  5004.5   72.93
  5066.6    88.7  5106.6    89.7  5146.6    95.5  5376.6      95  5516.6   107.5
  5676.6     108  5796.6      98  5916.6   109.1  6026.6   103.8  6106.6      91
  6196.6    87.8  6246.6    91.3  6327.1   103.4  6387.1    98.2  6497.1    98.5
  6557.1   102.5  6597.1      99  6937.1   103.2  7347.1    98.9  7517.1   105.3
  8037.1   103.1  8427.1   106.3  8617.1   106.6  8757.1   111.6  9518.5   114.7
#Mann= 5 ,-1 , 0
  4284.3     .14       0  4916.7    .042       0  5146.6     .06       0
  7347.1     .12       0  8427.1     .99       0
#XS Ineff= 2 , 0
                         8412.11          106.07
Permanent Ineff=
       F       F
#Block Obstruct= 3 ,-1
  5679.3 5918.37  107.32 6011.66 6332.36  102.97    6327  6937.1   103.2
Bank Sta=4916.7,5146.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,75290   ,448.6,1751,2256.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X26A
END DESCRIPTION:
XS GIS Cut Line= 4
      3081241.59     13937354.35      3081089.45     13935766.91
      3080557.32     13935498.02      3080491.03     13932299.15
#Sta/Elev= 30
  3058.8   114.2  3388.8   107.8  3648.8    98.2  3818.8   100.3  4268.8    99.6
  4408.8    96.5  4879.5   97.83  4918.3   94.91  4935.6   82.74  4956.7   82.13
  4981.4   74.93  5004.5    72.5  5018.3    74.6  5057.8   93.64  5066.3  100.89
  5259.7   102.1  5349.7    98.7  5479.7    98.8  5629.7     102    6114   95.94
  6279.7   101.8  6449.7     101  6659.7     106  6699.7   103.5  6939.7   103.1
  7269.7   106.5  7509.7   106.4  7779.7   112.5  7899.7   110.3  8449.3   114.6
#Mann= 5 ,-1 , 0
  3058.8     .14       0  4879.5    .042       0  5066.3     .06       0
    6114     .12       0  7269.7     .99       0
#XS Ineff= 2 , 0
                         7253.91          105.96
Permanent Ineff=
       F       F
Bank Sta=4879.5,5066.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,73539   ,1961,1782,1595.9
BEGIN DESCRIPTION:
Cross Section K100-00-00-X25B
END DESCRIPTION:
XS GIS Cut Line= 4
      3081478.84     13937237.81      3081453.86     13935930.86
      3082665.08     13934919.43      3084946.01     13933321.12
#Sta/Elev= 30
  2572.6   114.1  2742.6     111  3102.6    99.1  3182.6    98.3  3272.6    99.4
  3422.6    97.6  3602.6   100.2  3872.6   100.1  4439.8    96.5  4739.8    96.1
  4839.8      98  4922.3   95.36  4945.7   84.31  4993.7   70.47    5022   74.64
  5041.8    87.2  5052.5   101.8    5057  102.75  5059.8      97  5079.8   103.3
  5957.8   101.3  5977.8    98.7  5997.8   100.5  6177.8   102.5  6657.8     101
  7407.8   111.5  7647.8   109.8  7797.8   111.7  7917.8   109.9    8243   112.2
#Mann= 3 ,-1 , 0
  2572.6     .14       0  4922.3    .042       0    5057     .14       0
#XS Ineff= 2 , 0
                         6409.18           106.4
Permanent Ineff=
       F       F
Bank Sta=4922.3,5057
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,71757   ,280.4,237,322
BEGIN DESCRIPTION:
Cross Section XS25.3
END DESCRIPTION:
XS GIS Cut Line= 5
      3082061.44       13938321.      3083101.89     13936764.69
      3083158.11     13936676.35      3083456.26     13936128.37
      3084975.19     13933888.39
#Sta/Elev= 30
    3058   114.7    3428   114.6    3508   111.6    3738   110.4    3978   103.7
    4138   104.1    4258   103.1    4318    99.5    4498    95.4    4898    95.2
  4950.1    87.9  4970.2   74.07    5003   72.15  5029.8    74.1  5029.9   75.05
  5030.1    81.2  5054.8    89.6  5074.8    93.5  5174.8    94.1  5274.8   100.1
  5364.8    98.6  5708.7   101.6  5918.7    99.6  6018.7   102.3  6778.7   102.4
  6848.7    99.4  7068.7    99.9  7608.7   106.9  8008.7   109.4  8365.1   112.5
#Mann= 5 ,-1 , 0
    3058     .99       0    4138     .14       0    4898    .042       0
  5074.8     .14       0  8008.7     .99       0
#XS Ineff= 2 , 0
         4277.34  106.18 5718.75          105.73
Permanent Ineff=
       F       F
Bank Sta=4898,5074.8
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,71520   ,87.6,88,88.6
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3082489.03     13938356.62      3083166.06     13937152.97
      3083580.54     13936377.85      3085094.61     13934194.35
#Sta/Elev= 30
  3220.9  111.68  3470.9  111.18  3530.9  108.68  3660.9  109.58  3900.9  108.98
  3920.9  107.78  4090.9  108.48  4173.8  106.73  4310.9  101.68  4350.9   96.88
  4410.9   97.08  4490.9   93.58  4602.9   92.53  4756.7   94.65  4943.4   90.32
  4970.2   74.31    5003   72.39  5029.8   74.34  5065.9   95.02  5480.9   97.78
  5730.9  103.78  5980.9  100.28  6570.9  101.78  6800.9  100.28  6820.9   98.58
  6840.9   99.78  7170.9   99.08  7460.9  101.58  7946.5  108.21    8138  110.98
#Mann= 5 ,-1 , 0
  3220.9     .99       0  4173.8     .14       0  4943.4    .042       0
  5065.9     .14       0  7946.5     .99       0
#XS Ineff= 2 , 0
       0    4725   104.6 5302.73       0  104.61
Permanent Ineff=
       F       F
Bank Sta=4943.4,5065.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,71478   ,,,
BEGIN DESCRIPTION:
KUYKENDAHL
Structure ID: K100-00-00-S10
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,64,2.6,0, 119, 119, , , .95, 0, ,,,
  3220.9  3410.9  3440.9  3470.9  3530.9  3540.9  3550.9  3570.9  3600.9  3610.9
  3640.9  3650.9  3660.9  3900.9  3920.9  4040.9  4090.9  4173.8  4180.9  4220.9
  4240.9  4260.9  4273.8  4310.9  4340.9  4350.9  4380.9  4410.9  4483.8  4490.9
  4511.3 4511.39  4511.5 4511.61  4540.9  4560.6  4561.8  4602.9  4617.6  4656.8
    4675  4696.6  4705.4 4735.81 4735.92 4735.99  4756.7  4758.3  4797.2  4857.6
    4919  4943.4  4969.5    4970  4970.2    5003  5029.8  5029.9  5032.1  5065.9
  5101.1  5163.2  5223.5  5264.8  5268.6  5284.4 5284.71  5284.8 5284.89    5285
  5327.2  5360.8  5382.3  5408.6    5437  5460.4 5460.49  5460.6 5460.71  5480.9
  5650.9  5730.9  5770.9  5780.9  5800.9  5810.9  5850.9  5880.9  5910.9  5930.9
  5946.5  6570.9  6610.9  6750.9  6780.9  6800.9  6810.9  6820.9  6830.9  6840.9
  7170.9  7190.9  7220.9  7460.9  7500.9  7510.9  7530.9  7560.9  7590.9  7610.9
  7740.9  7780.9  7800.9  7860.9  7900.9  7946.5  8060.9  8100.9    8138
   112.7   112.6   111.8   112.2   109.7   109.8   110.3   109.7   109.6     110
   110.3   109.7   110.6     110   108.8   108.8   109.5  107.75   107.6   106.5
   105.3   105.4   105.2  105.09  105.01  104.98  104.89  104.81   104.6  104.65
  104.81  104.81  105.81  105.81  106.03  106.17  106.18  106.65  106.82   107.2
  107.38  107.58  107.65  107.91  107.91  107.91  108.08   108.1  108.42  108.58
  108.72  108.72  108.72  108.72  108.72  108.72  108.73  108.73  108.73  108.73
  108.73  108.67   108.5  108.38  108.37  108.33  108.28  108.26  108.26  108.26
  107.83  107.49  107.33  107.14  106.94  106.78  106.78  106.78  105.78  105.76
  105.63  105.57  105.54  105.53  105.51  105.51  105.47  105.45  105.43  105.41
   105.4   102.8   102.1   101.7   100.9   101.3   100.8    99.6    99.9   100.8
   100.1     101   100.3   102.6     104   103.8   104.8   104.7   105.3   104.9
   105.9   106.5     108     109   108.6  109.23   110.8   111.9     112
                                                                                
                                                                                
                                                                                
                                                                                
                                            99.4   99.57   99.59   99.91  100.07
  100.21  100.21  100.21  100.21  100.21  100.21  100.22  100.22  100.22  100.22
  100.22  100.16   99.99   99.87   99.86   99.82   99.77
                                                                                
                                                                                
                                                                                
                                                                                
                                                                        
  3220.9  3410.9  3440.9  3470.9  3530.9  3540.9  3550.9  3570.9  3600.9  3610.9
  3640.9  3650.9  3660.9  3900.9  3920.9  4040.9  4090.9  4173.8  4180.9  4220.9
  4240.9  4260.9  4273.8  4310.9  4340.9  4350.9  4380.9  4410.9  4483.8  4490.9
  4511.3 4511.39  4511.5 4511.61  4540.9  4560.6  4561.8  4602.9  4617.6  4656.8
    4675  4696.6  4705.4 4735.81 4735.92 4735.99  4756.7  4758.3  4797.2  4857.6
    4919  4943.4  4969.5    4970  4970.2    5003  5029.8  5029.9  5032.1  5065.9
  5101.1  5163.2  5223.5  5264.8  5268.6  5284.4 5284.71  5284.8 5284.89    5285
  5327.2  5360.8  5382.3  5408.6    5437  5460.4 5460.49  5460.6 5460.71  5480.9
  5650.9  5730.9  5770.9  5780.9  5800.9  5810.9  5850.9  5880.9  5910.9  5930.9
  5946.5  6570.9  6610.9  6750.9  6780.9  6800.9  6810.9  6820.9  6830.9  6840.9
  7170.9  7190.9  7220.9  7460.9  7500.9  7510.9  7530.9  7560.9  7590.9  7610.9
  7740.9  7780.9  7800.9  7860.9  7900.9  7946.5  8060.9  8100.9    8138
   112.7   112.6   111.8   112.2   109.7   109.8   110.3   109.7   109.6     110
   110.3   109.7   110.6     110   108.8   108.8   109.5  107.75   107.6   106.5
   105.3   105.4   105.2  105.09  105.01  104.98  104.89  104.81   104.6  104.65
  104.81  104.81  105.81  105.81  106.03  106.17  106.18  106.65  106.82   107.2
  107.38  107.58  107.65  107.91  107.91  107.91  108.08   108.1  108.42  108.58
  108.72  108.72  108.72  108.72  108.72  108.72  108.73  108.73  108.73  108.73
  108.73  108.67   108.5  108.38  108.37  108.33  108.28  108.26  108.26  108.26
  107.83  107.49  107.33  107.14  106.94  106.78  106.78  106.78  105.78  105.76
  105.63  105.57  105.54  105.53  105.51  105.51  105.47  105.45  105.43  105.41
   105.4   102.8   102.1   101.7   100.9   101.3   100.8    99.6    99.9   100.8
   100.1     101   100.3   102.6     104   103.8   104.8   104.7   105.3   104.9
   105.9   106.5     108     109   108.6  109.23   110.8   111.9     112
                                                                                
                                                                                
                                                                                
                                                                                
                                            99.4   99.57   99.59   99.91  100.07
  100.21  100.21  100.21  100.21  100.21  100.21  100.22  100.22  100.22  100.22
  100.22  100.16   99.99   99.87   99.86   99.82   99.77
                                                                                
                                                                                
                                                                                
                                                                                
                                                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4796.9, 2 ,4796.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   92.24  100.91
     1.5     1.5
   94.26  102.93
Pier Skew, UpSta & Num, DnSta & Num=  ,4857.8, 2 ,4857.8, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   91.03  101.07
     1.5     1.5
   93.05  103.09
Pier Skew, UpSta & Num, DnSta & Num=  ,4918.3, 2 ,4918.3, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   89.82  101.21
     1.5     1.5
   91.84  103.23
Pier Skew, UpSta & Num, DnSta & Num=  ,4980.1, 2 ,4980.1, 2 , 0 , 0 , 0 ,,
     1.5     1.5
    72.7  101.21
     1.5     1.5
   74.72  103.23
Pier Skew, UpSta & Num, DnSta & Num=  ,5041.3, 2 ,5041.3, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   80.12  101.22
     1.5     1.5
   82.14  103.24
Pier Skew, UpSta & Num, DnSta & Num=  ,5101.9, 2 ,5101.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   94.17  101.22
     1.5     1.5
   96.19  103.24
Pier Skew, UpSta & Num, DnSta & Num=  ,5163, 2 ,5163, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   94.43  101.16
     1.5     1.5
   96.45  103.18
Pier Skew, UpSta & Num, DnSta & Num=  ,5223.9, 2 ,5223.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   94.67  100.99
     1.5     1.5
   96.69  103.01
BR Coef= 1 , 1 , 1 ,1.25, 0 ,,,.8,-1,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=111.68

Type RM Length L Ch R = 1 ,71432   ,266.2,253,289.6
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 4
      3082569.52     13938391.32      3083246.66     13937187.48
      3083660.69     13936413.19       3085174.1     13934230.64
#Sta/Elev= 30
  3220.9  113.69  3470.9  113.19  3530.9  110.69  3660.9  111.59  3900.9  110.99
  3920.9  109.79  4090.9  110.49  4173.8  108.74  4310.9  103.69  4350.9   98.89
  4410.9   99.09  4490.9   95.59  4602.9   94.54  4756.7   96.66  4943.4   92.33
  4970.2   76.32    5003    74.4  5029.8   76.35  5065.9   97.03  5480.9   99.79
  5730.9  105.79  5980.9  102.29  6570.9  103.79  6800.9  102.29  6820.9  100.59
  6840.9  101.79  7170.9  101.09  7460.9  103.59  7946.5  110.22    8138  112.99
#Mann= 5 ,-1 , 0
  3220.9     .99       0  4173.8     .14       0  4943.4    .042       0
  5065.9     .14       0  7946.5     .99       0
#XS Ineff= 2 , 0
       0    4725   104.5  5295.4       0     105
Permanent Ineff=
       F       F
Bank Sta=4943.4,5065.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,71179.  ,214.1,212,234.3
BEGIN DESCRIPTION:
K100-00-00-S10_KUYKENDAHL -DS - XS1
END DESCRIPTION:
XS GIS Cut Line= 4
      3082766.74       13938491.      3083443.88      13937287.2
       3083889.2     13936596.09      3085371.32     13934330.36
#Sta/Elev= 30
  3238.1  113.22  3708.1  112.66  4148.1  108.52  4428.1   97.42  4909.3   97.07
  4919.3   95.44  4959.3   80.59 4992.55   73.91 5024.81   75.79  5049.3   81.47
  5079.3   94.11  5099.3      96  5369.3   97.38  5551.5  102.64  5781.5  102.39
  5871.5  100.03  6241.5  101.73  6301.5  104.48  6641.5  103.45  6671.5   104.7
  6711.5  100.89  6841.5  102.02  7051.5   99.79  7361.5  103.27  7541.5  107.78
  7731.5  107.07  7771.5  110.87  7981.5  109.07  8041.5  113.46  8148.9  113.68
#Mann= 7 ,-1 , 0
  3238.1      .1       0  3708.1     .12       0  4909.3   .0385       0
  5099.3     .12       0  6241.5     .08       0  6641.5     .12       0
  7361.5     .08       0
#XS Ineff= 2 , 0
                         5624.11          104.36
Permanent Ineff=
       F       F
Bank Sta=4909.3,5099.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,70967   ,965.7,974,916.3
BEGIN DESCRIPTION:
Cross Section XS25.1
END DESCRIPTION:
XS GIS Cut Line= 6
      3082847.49      13938651.5      3083734.61      13937174.8
      3083751.82      13937159.7      3083799.15     13937112.37
      3083834.55     13937077.15      3085515.78     13934433.13
#Sta/Elev= 30
  3210.5     112  3270.5   110.2  3330.5   112.6  3510.5   112.2  3540.5   109.7
  3840.5   111.5  4070.5   106.7  4190.5   106.9  4350.5    99.2  4490.5    96.3
  4910.5    98.2  4943.2    93.2  4983.8    73.5  5022.5   75.45  5033.6   81.75
    5043    83.2    5063    92.1  5082.9    95.2  5252.9    93.9  5482.9   101.7
  5732.9     103  6282.9   101.3  6372.9   104.5  6632.9   104.1  6792.9    99.9
  7522.9   108.8  7782.9   108.4  7902.9   111.2  7992.9   108.9  8206.2   114.7
#Mann= 5 ,-1 , 0
  3210.5     .99       0  4190.5     .14       0  4910.5   .0385       0
  5082.9     .14       0  7992.9     .99       0
#XS Ineff= 2 , 0
                         5683.59          103.93
Permanent Ineff=
       F       F
Bank Sta=4910.5,5082.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,69993   ,797.3,953,751
BEGIN DESCRIPTION:
Cross Section K100-00-00-X25A
END DESCRIPTION:
XS GIS Cut Line= 4
      3083716.92       13938834.      3084217.57     13938142.12
      3084748.24      13937414.1      3085756.85     13934719.42
#Sta/Elev= 30
    3786   110.5    3976   108.5    4026   110.7    4366     109  4466.5  106.49
    4670   100.9    4810    93.1  4925.2   93.92  4970.9   79.05  4977.6   73.54
  4983.8   71.58  5022.5   73.53    5058    90.5  5065.3   98.22    5400    96.8
  5540.9    91.5  5830.9    99.9  6110.9     101  6170.9    99.5  6890.9   101.3
  7180.9    99.1  7360.9     101  7480.9   104.8  7630.9   103.5  8010.9   108.3
  8060.9   106.5  8100.9   111.8  8260.9   109.4  8350.9   114.4  8418.2     115
#Mann= 5 ,-1 , 0
    3786     .99       0  4466.5     .14       0  4925.2   .0385       0
  5065.3     .14       0  6110.9     .99       0
Bank Sta=4925.2,5065.3
XS Rating Curve= 0
Exp/Cntr=.3,.1
