HEC-RAS study M112-00-00.prj: M112-00-00

--- M112-00-00.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,3423.9  ,577.78,541.9,462.85
BEGIN DESCRIPTION:
Cross Section 3423.9
Cross Section XS-03
END DESCRIPTION:
XS GIS Cut Line= 2
      3054963.29      13963228.8      3054546.93      13961277.1
#Sta/Elev= 30
  3775.3   143.8  3865.3   143.6  4145.3   141.9  4205.3   142.2  4305.3   140.6
  4345.3   141.3  4385.3     141  4455.3   138.6  4575.3   137.3  4865.3   136.4
  4893.9   135.2  4953.6  134.08    4979  134.62  4994.7   129.7    5000  129.19
  5004.9  129.56  5010.2  132.68  5016.9  134.89  5073.5  136.41  5101.2  136.97
  5135.3     137  5145.3   137.6  5195.3   138.9  5335.3   140.9  5355.3   140.7
  5465.3   141.5  5565.3   141.1  5615.3   141.6  5715.3   141.8  5770.9   142.5
#Mann= 5 ,-1 , 0
  3775.3     .09       0    4979     .04       0  5016.9     .09       0
  5073.5     .05       0  5770.9      .2       0
#XS Ineff= 2 , 0
       0    4979  134.62               0
Permanent Ineff=
       F       F
Bank Sta=4979,5016.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,2882.0  ,570.79,594.8,582.59
BEGIN DESCRIPTION:
Cross Section XS-02.5
END DESCRIPTION:
XS GIS Cut Line= 2
      3055200.31      13962894.4      3055267.06      13961551.9
#Sta/Elev= 30
  4168.1   142.3  4208.1   142.1  4248.1   142.3  4278.1     142  4348.1   142.5
  4488.1   140.9  4558.7  139.56  4618.1   138.6  4638.1   137.8  4668.1   138.1
  4808.1   135.8  4838.1   135.9  4868.1   135.6  4908.1   134.4  4928.1   134.3
  4968.1   133.4  4979.2  132.35  4998.1   129.6    5000  127.42  5006.4  130.11
    5017  131.17  5038.1   133.6  5058.1   135.2  5088.1   136.7  5107.8     137
  5138.1   136.9  5238.1   138.9  5348.1   142.5  5398.1   142.9  5512.3   144.8
#Mann= 6 , 1 , 0
  4168.1      .2       0  4168.1     .12       0  4558.7     .14       0
  4979.2     .04       0    5017     .14       0  5107.8     .05       0
Bank Sta=4979.2,5017
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,2287.2  ,762.03,679.3,607.62
BEGIN DESCRIPTION:
Cross Section 2287.2
Cross Section XS-02
END DESCRIPTION:
XS GIS Cut Line= 2
      3055824.17      13962787.7      3055787.38       13961529.
#Sta/Elev= 30
    4386   141.1    4406   140.8    4436     141    4466   140.4    4556   139.5
    4586   139.5    4626   138.5    4756   137.6    4806   135.9    4896   133.4
  4908.4   134.1  4952.8  134.33  4979.2   133.9  4986.5   131.8  4992.9  128.75
  4993.6  128.12    5000  125.49  5006.4  128.18  5011.6  131.44    5017   133.6
  5047.1   134.6    5066   133.8    5126   135.1    5166   136.8  5305.7  139.01
    5336   139.8    5376   141.5    5546   144.9    5606   146.5  5645.3   148.5
#Mann= 6 , 1 , 0
    4386      .2       0    4386     .14       0  4979.2     .04       0
    5017     .14       0  5305.7     .05       0  5645.3      .2       0
#XS Ineff= 2 , 0
       0  4952.8  134.33               0
Permanent Ineff=
       F       F
Bank Sta=4979.2,5017
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,1607.9  ,381.59,626.8,696.82
BEGIN DESCRIPTION:
Cross Section 1607.9
Cross Section XS-01b
END DESCRIPTION:
XS GIS Cut Line= 2
       3056303.1      13962889.1      3056551.39       13961639.
#Sta/Elev= 30
  4154.1   141.4  4244.1   140.7  4364.1   138.6  4484.1   137.4  4514.1   136.6
  4594.1     136  4794.1   136.8  4964.1   131.6  4979.2  130.59  4994.1   128.9
    5000  123.72  5004.1   128.6    5017  130.11  5024.1   131.1  5044.1   132.4
  5104.1   134.3  5134.1   134.9  5174.1     135  5214.1   135.9  5234.1   137.8
  5264.1   138.1  5274.1   138.9  5284.1   140.4  5314.1   140.5  5334.1   141.5
  5344.1   142.5  5364.1   143.4  5384.1   143.8  5404.1   143.1  5428.6   143.7
#Mann= 4 , 1 , 0
  4154.1      .2       0  4154.1     .14       0  4979.2     .04       0
    5017     .14       0
Bank Sta=4979.2,5017
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,981.1   ,559.99,576,436.85
BEGIN DESCRIPTION:
Cross Section 981.1
Cross Section XS-01a
END DESCRIPTION:
XS GIS Cut Line= 4
      3057182.15      13962683.8      3057052.17      13962037.4
      3056935.88      13961931.4      3056764.86      13961168.6
#Sta/Elev= 30
  4260.8     142  4330.8   141.9  4369.8  142.51  4410.8   143.1  4420.8   142.9
  4450.8   141.3  4570.8   140.6  4620.8     139  4820.8   135.5  4920.2   132.3
  4950.2   131.7  4960.2   131.3  4963.2  130.31  4981.2  130.38  4988.2  128.07
  4996.3  122.93    5001  122.09  5016.7  126.68  5029.3  131.09  5070.2   131.1
  5107.6   132.5  5257.6   134.3  5337.6   133.9  5447.6   135.9  5637.6   141.4
  5677.6   141.1  5710.2   139.8  5757.6   138.3  5787.6   138.2  5859.3   139.2
#Mann= 6 ,-1 , 0
  4260.8     .11       0  4369.8     .14       0  4981.2     .04       0
  5029.3     .14       0  5710.2     .13       0  5859.3      .2       0
Bank Sta=4981.2,5029.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,405.1   ,0,0,0
BEGIN DESCRIPTION:
Cross Section 405.1
Cross Section XS-01
END DESCRIPTION:
XS GIS Cut Line= 3
      3057487.46      13962760.3      3057506.98      13961745.5
       3057181.7      13960938.8
#Sta/Elev= 30
    4159     142    4239   141.3    4269   141.8    4299   140.7    4359   141.2
    4429   140.3    4579   140.1  4635.7  140.95    4659   141.3    4689   139.6
    4749   138.7    4779   138.9    4819   137.7    4949   130.1  4963.2  128.82
  4981.2  128.89  4988.2  126.58  4996.3  121.44    5001   120.6  5016.7  125.19
  5029.3   129.6  5042.5  130.72  5068.6  129.18    5099   129.9  5174.1   133.3
  5514.1   133.9  5574.1   135.6  5844.1     140  6017.3  141.13  6043.9   141.3
#Mann= 6 ,-1 , 0
    4159     .11       0  4635.7     .14       0  4981.2     .04       0
  5029.3     .14       0  6017.3     .13       0  6043.9      .2       0
#XS Ineff= 2 , 0
       0                  5042.5       0  130.72
Permanent Ineff=
       F       F
Bank Sta=4981.2,5029.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Chan Stop Cuts=-1
