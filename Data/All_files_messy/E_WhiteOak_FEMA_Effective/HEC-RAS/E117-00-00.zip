HEC-RAS study E117_baker.prj: E117-00-00

--- E117_baker.g02 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,2604    ,100.5,102,100.1
BEGIN DESCRIPTION:
Bolivia - 2
END DESCRIPTION:
XS GIS Cut Line= 4
      3087867.3213873228.5767042      3088023.75     13872226.23
      3088063.67     13871914.34      3088054.28     13870888.51
#Sta/Elev= 30
  3881.9   82.46  3891.9   78.86  3911.9   74.86  3951.9   73.36  4191.9   72.36
  4261.9   73.86  4411.9   73.46  4491.9   71.36    4521    72.7  4761.9   69.76
  4939.6   69.72  4952.1    69.8  4998.3   50.54    5019   55.93  5059.4    70.6
  5074.1   70.47  5241.9   70.06  5271.9   73.06    5375      74  5441.9   71.96
  5481.9   75.06  5561.9   75.76  5651.9   73.76  5701.9   73.96  5751.9   76.66
  5871.9   76.56  5901.9   74.46  5931.9   74.46  5971.9   76.06  6239.7   77.06
#Mann= 7 ,-1 , 0
  3881.9     .99       0    4521     .08       0  4939.6     .04       0
  4952.1     .04       0  5059.4     .04       0  5074.1     .08       0
    5375     .99       0
#XS Ineff= 2 , 0
       0    4958   69.77  5057.5       0   69.97
Permanent Ineff=
       F       F
Bank Sta=4952.1,5059.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,2502    ,875.3,874,870.2
BEGIN DESCRIPTION:
Bolivia - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 5
      3087899.28      13873227.5      3087999.28     13873031.56
      3088122.76     13872240.29      3088163.73     13871920.26
      3088154.27      13870887.6
#Sta/Elev= 30
  3863.9   76.19  3883.9   74.57  3953.9   73.57  4183.9   72.64  4313.9   73.76
  4493.9   71.87  4643.9   72.65  4763.9   69.49  4803.9   71.01  4924.8   71.19
    4951   69.82  4966.3   64.43  4985.2   52.14  5003.3   50.52  5012.5   51.22
  5016.1   52.94  5021.7    59.3  5046.1    68.3  5074.8   70.23  5084.8    71.3
  5237.4   70.31  5297.4   73.32  5377.4   73.49  5427.4   71.89  5497.4   75.63
  5647.4   73.84  5757.4   77.28  5907.4   73.87  5957.4   75.68  6240.1   76.59
#Mann= 7 ,-1 , 0
  3863.9     .99       0  4493.9     .08       0  4924.8     .04       0
    4951     .04       0  5046.1     .04       0  5074.8     .08       0
  5377.4     .99       0
Bank Sta=4951,5046.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,1628    ,741.4,706,666.8
BEGIN DESCRIPTION:
Cross Section XS02
Located At: DS HARDWAY
Levee in left overbank is not a certified Levee
END DESCRIPTION:
XS GIS Cut Line= 6
      3087879.3913873279.5678014      3088147.93     13873027.85
        3088836.     13872962.84      3088982.96     13872453.13
      3089025.34     13871986.98 3089247.736088713871082.9371997
#Sta/Elev= 30
  3107.6    83.7  3137.6    76.3  3147.6    75.1  3257.6    73.5  3307.6    74.3
  3367.6    73.4  4186.8    71.4  4256.8    69.6  4406.8    70.4  4456.8    68.5
  4697.3      70  4767.3    68.6  4917.3    69.9  4927.3    69.7    4951   69.63
  4966.3   64.24  4985.2   51.95  5003.3   50.33  5012.5   51.03  5016.1   52.75
  5021.7   59.11  5046.1   68.11  5073.4   68.45  5165.4    68.1    5698   76.77
  5765.4    75.7  5965.4    79.3  6005.4    77.7  6055.4    79.2  6096.5    78.1
#Mann= 7 ,-1 , 0
  3107.6     .99       0  4917.3     .08       0  4927.3     .04       0
    4951     .04       0  5046.1     .04       0  5073.4     .07       0
    5698     .99       0
#XS Ineff= 2 , 0
         4916.59    69.9
Permanent Ineff=
       F       F
Bank Sta=4951,5046.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,922     ,659.1,679,696
BEGIN DESCRIPTION:
Cross Section XS01
Located At: DS BOLIVIA
END DESCRIPTION:
XS GIS Cut Line= 6
      3087876.1413873322.7085498      3088156.99     13873069.72
      3089331.07     13872860.15      3089712.34     13872557.16
      3089766.04     13872148.07      3089379.23     13871220.86
#Sta/Elev= 30
  2372.4    84.4  2402.4    76.7  2422.4    75.1  2614.6   73.31  3056.2    73.4
    3427      71  4257.3    68.6  4407.4    68.7  4437.4    69.8  4557.4      69
  4627.4    66.9  4677.4    68.7  4777.4    68.7  4885.2    70.1  4905.2    71.7
  4927.1   71.23  4946.4   71.68  4965.2   62.75  4984.4   55.57  4987.3   52.84
  4998.9    51.4  5012.6   52.78  5014.6   55.95  5054.7   69.44  5095.2    72.7
  5145.2      72  5204.9    74.4    5686    75.7    5786    78.3  5864.5    83.7
#Mann= 7 ,-1 , 0
  2372.4     .05       0  2614.6     .08       0  4927.1     .04       0
  4946.4     .04       0  5054.7     .04       0  5095.2     .08       0
  5864.5      .2       0
#XS Ineff= 2 , 0
         4682.43   68.58
Permanent Ineff=
       F       F
Bank Sta=4946.4,5054.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,243     ,87.9,110,130
BEGIN DESCRIPTION:
E117-00-00-Dam-S1A-4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 6
      3088282.96       13873076.      3088860.78     13873041.56
      3089332.17     13872872.12        3090301.     13871885.91
       3090207.6     13871566.58      3089714.49     13871381.94
#Sta/Elev= 30
  2367.2   73.55  2587.2   73.69  2907.2   70.94    3577   69.02  3918.4   69.75
  4218.4   69.22  4498.4   65.76  4638.4    65.9  4748.4   67.91  4927.1      70
  4946.4   70.45  4965.2   61.52  4984.4   54.34  4987.3   51.61  4989.9   50.81
  4998.9   50.17  5012.6   51.55  5014.6   54.72  5054.7   68.21  5067.9   68.33
  5087.9   70.43    5110   70.15  5192.8   69.09  5252.8   70.85    5325   71.56
  5532.8   73.12  5572.8   74.72  5632.8   74.95  5672.8   76.67  5719.3   76.87
#Mann= 6 ,-1 , 0
  2367.2     .08       0  4927.1     .04       0  4946.4     .04       0
  5087.9     .04       0    5110     .12       0    5325     .08       0
Bank Sta=4946.4,5087.9
XS Rating Curve= 0
Exp/Cntr=.7,.5

Type RM Length L Ch R = 1 ,133     ,24.8,22,22.7
BEGIN DESCRIPTION:
E117-00-00-Dam-S1A-3
END DESCRIPTION:
XS GIS Cut Line= 6
 3088302.5684542 13873086.266207      3088858.95     13873054.92
      3089332.19     13872885.82      3090409.02     13871787.62
      3090275.33     13871464.42  3089748.80587413871262.5912238
#Sta/Elev= 30
  2322.4   90.52  2362.4   86.52  2402.4   76.72  2422.4   75.12  2572.4   73.42
  3056.2   73.42    3427   71.02  4257.3   68.62  4437.4   69.82  4557.4   69.02
  4627.4   66.92  4677.4   68.72  4855.2   70.12  4884.5   67.75  4927.5   69.55
  4959.8   56.71  4975.1   57.43  4982.7   55.09  4987.5   51.36  5009.5   49.97
  5016.8   53.66  5043.2    57.3  5074.9   71.21  5112.7   69.76  5148.8   69.64
  5204.9   74.42  5439.4   75.46    5716   76.22    5786   78.32  5864.5   83.72
#Mann= 4 ,-1 , 0
  2322.4     .08       0  4884.5     .04       0  5112.7     .12       0
  5439.4     .08       0
#XS Ineff= 2 , 0
       0  4932.9    68.5  5073.5       0    70.4
Permanent Ineff=
       F       F
Bank Sta=4927.5,5074.9
XS Rating Curve= 0
Exp/Cntr=.7,.5

Type RM Length L Ch R = 5 ,122.5   ,,,
BEGIN DESCRIPTION:
DROP STRUCTURE 100' U/S E100 CONFLUENCE
Structure ID: E117-00-00-S1A
END DESCRIPTION:
IW Pilot Flow=0
#Inline Weir SE= 30
  1779.3    90.3  2322.4   90.51  2362.4   86.51  2402.4   76.71  2422.4   75.11
  2572.4   73.41  3056.2   73.41    3427   71.01  4257.3   68.61  4407.4   68.71
  4437.4   69.81  4557.4   69.01  4607.4   67.01  4677.4   68.71  4927.5   69.54
    4933   68.55  4963.2   56.86  4975.1   57.42  4980.5   56.33  4989.6   51.98
  5008.4   51.87  5017.1   56.39  5036.4   56.87  5074.9    71.2  5164.4   70.96
  5204.9   74.41    5686   75.71    5786   78.31  5864.5   83.71  5911.7    76.3
IW Dist,WD,Coef,Skew,MaxSub,Min_El,Is_Ogee,SpillHt,DesHd
10,1,3,0,.95,, 0 ,,,.1,.1,

Type RM Length L Ch R = 1 ,111     ,0,0,0
BEGIN DESCRIPTION:
E117-00-00-Dam-S1A-2
Located At: DROP STRUCTURE 100' U/S E100 CONFLUENCE
END DESCRIPTION:
XS GIS Cut Line= 6
      3088327.6913873093.3379531      3089352.04     13872892.77
      3089737.93     13872606.83      3090431.37     13871792.08
       3090295.9     13871462.75 3089774.228452813871262.7742541
#Sta/Elev= 30
  2322.4    90.5  2362.4    86.5  2402.4    76.7  2422.4    75.1  2572.4    73.4
  3056.2    73.4  4257.3    68.6  4437.4    69.8  4557.4      69  4627.4    66.9
  4677.4    68.7  4855.2    70.1  4872.5   67.82  4902.7   68.81  4928.8   69.98
  4967.7   54.03  4973.5   53.63  4990.5   45.16  5010.5   45.38  5026.4   53.75
  5032.2   53.86    5076   71.65  5112.7   70.72  5136.4    69.8  5145.2      72
  5204.9    74.4  5439.4   75.44    5716    76.2    5786    78.3  5864.5    83.7
#Mann= 6 ,-1 , 0
  2322.4     .08       0  4902.7     .04       0  4928.8    .015       0
    5076     .04       0  5112.7     .12       0  5439.4     .08       0
#XS Ineff= 2 , 0
       0  4932.9    68.5  5073.5       0    70.4
Permanent Ineff=
       F       F
Bank Sta=4928.8,5076
XS Rating Curve= 0
Exp/Cntr=.7,.5

Chan Stop Cuts=-1

--- E117_baker.g01 (geometry) ---

Geom Title=TSARP Geometry (04/23/04)
Version=Version 3.0.1  Mar 2001

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
River Reach=E117-00-00      ,Reach - 1

Type RM Length L Ch R = 1 ,28684   ,444.7,382,370.4
BEGIN DESCRIPTION:
Gessner - 1
Interpolated channel, LIDAR overbanks
Right overbank spills to an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 3
       3064664.4      13881973.4      3065073.31     13879194.77
      3065278.49     13878977.97
#Sta/Elev= 30
  2321.4   97.58  3231.4   94.94  3441.4   95.56  3801.4   94.42  3821.4   95.55
  3851.4   94.71  3881.4   95.53  3941.4   95.52  4001.4   95.37  4041.4   92.28
  4121.4   93.43  4151.4   92.02  4191.4   94.18  4231.4   94.23  4351.4   93.69
  4391.4   94.94  4441.4   93.21  4571.4   92.56  4601.4   93.29  4641.4   92.06
  4974.6    91.7  4995.6    80.7  4996.4   79.62  4999.3   79.05  5002.7   79.19
  5004.3   80.72  5029.9   92.46  5051.4   94.98    5130   94.43  5428.5   93.74
#Mann= 7 ,-1 , 0
  2321.4     .99       0  4121.4     .12       0  4231.4     .04       0
  4571.4     .08       0  4974.6     .04       0  5029.9     .05       0
    5130     .99       0
Bank Sta=4974.6,5029.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,28302   ,396,416,413.3
BEGIN DESCRIPTION:
Windfern - 4
Cross Section xs 22
Located At: US WINDFERN
END DESCRIPTION:
XS GIS Cut Line= 3
      3065082.75     13881943.18      3065509.31     13879746.08
      3065281.77     13878756.88
#Sta/Elev= 30
  2400.9    94.3  3110.9    93.9  3160.9    95.1  3870.9    93.9  3900.9    92.9
  3930.9    94.6  4110.9    94.4  4140.9    93.2    4300   93.77  4370.9    90.6
  4390.9    91.5  4420.9    93.6  4450.9    93.7  4500.9    90.5  4510.9    89.9
  4570.9      93    4849    91.5    4959    91.3  4965.5    92.1  4974.6   91.41
  4996.4   79.33  4999.3   78.76  5002.7    78.9  5029.9   92.17    5042   92.77
  5080.8   94.68  5135.4   94.19    5519    93.5    5559    92.4  5654.1    93.8
#Mann= 8 ,-1 , 0
  2400.9     .99       0    4300     .12       0  4390.9     .04       0
  4500.9     .08       0  4965.5     .04       0    5042     .05       0
  5135.4     .99       0  5654.1      .2       0
Bank Sta=4974.6,5029.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,27886   ,113.4,108,104.6
BEGIN DESCRIPTION:
Windfern - 3
Left overbank spills to E100-00-00.
Right overbank spills to an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 3
      3065667.13       13881265.       3065753.9     13879174.26
      3065748.94     13878584.97
#Sta/Elev= 30
  2908.7   93.17  3050.7   93.52  3090.7   92.42  3350.7   92.92  3470.7   94.02
  3610.7   93.32  3690.7   91.22    3930   92.94  3970.7   92.02  4090.7   91.82
  4140.7   92.52  4340.7   91.42  4360.7   92.72  4520.7   92.22  4788.7   92.38
  4868.7   94.22  4878.9   95.26  4928.9   92.13  4961.3   91.47    4980   80.63
  4994.6   80.34  4999.7   77.29  5003.8   78.57  5004.5   81.59  5019.9   91.84
  5060.6   93.14  5113.2   94.76  5221.3   92.52  5531.3   92.62  5590.6   91.82
#Mann= 8 ,-1 , 0
  2908.7     .99       0    3930     .12       0  4360.7     .04       0
  4520.7     .07       0  4868.7     .08       0  4961.3     .04       0
  5019.9     .08       0  5060.6     .99       0
#XS Ineff= 2 , 0
       0    4967    91.8  5018.5       0    91.8
Permanent Ineff=
       F       F
Bank Sta=4961.3,5019.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,27778   ,215.4,210,202.9
BEGIN DESCRIPTION:
Windfern - 2
Left overbank spills to E100-00-00
Right overbank spills to an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 3
 3065769.440337613881266.1030697      3065856.21     13879175.18
      3065851.25     13878585.76
#Sta/Elev= 30
  2908.7   93.17  3050.7   93.52  3090.7   92.42  3350.7   92.92  3470.7   94.02
  3610.7   93.32  3690.7   91.22    3930   92.94  3970.7   92.02  4090.7   91.82
  4140.7   92.52  4340.7   91.42  4360.7   92.72  4520.7   92.22  4788.7   92.38
  4868.7   94.22  4878.9   95.26  4928.9   92.13  4961.3   91.47    4980    80.1
  4994.6   79.81  4997.1   78.16  5001.5   77.52  5002.8   78.04  5004.5   81.06
  5019.9   91.84  5113.2   94.76  5221.3   92.52  5531.3   92.62  5590.6   91.82
#Mann= 8 ,-1 , 0
  2908.7     .99       0    3930     .12       0  4360.7     .04       0
  4520.7     .07       0  4868.7     .08       0  4961.3     .04       0
  5019.9     .08       0  5221.3     .99       0
#XS Ineff= 2 , 0
       0    4967      90 5018.54       0      90
Permanent Ineff=
       F       F
Bank Sta=4961.3,5019.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,27568   ,305,301,296.2
BEGIN DESCRIPTION:
Windfern - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 3
      3065961.89      13881452.2      3066056.24     13879178.48
       3066051.9     13878369.06
#Sta/Elev= 30
  2666.7   93.35  3196.7   93.25  3506.7   91.89    3800   92.27  4126.7   92.35
  4306.7   91.24  4336.7   91.94  4396.7   91.22  4426.7   89.81  4456.7   92.29
  4486.7   92.52  4526.7   90.13  4566.7   93.05  4626.7   93.29  4876.7   92.92
  4961.3   90.94    4980    80.1  4994.6   79.81  4997.1   78.16  5001.5   77.52
  5002.8   78.04  5004.5   81.06  5019.9   91.31  5102.4   97.28  5132.4   97.12
  5252.4   90.86    5400   91.35  5672.4   91.53  5702.4   93.09  5751.8   93.77
#Mann= 8 ,-1 , 0
  2666.7     .99       0    3800     .08       0  4486.7     .07       0
  4961.3     .04       0  5019.9     .04       0  5102.4     .12       0
  5252.4     .05       0    5400     .99       0
Bank Sta=4961.3,5019.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,27267   ,1347.1,1329,1347.6
BEGIN DESCRIPTION:
Cross Section XS21
Left overbank spills to E117
Located At: DS WINDFERN
END DESCRIPTION:
XS GIS Cut Line= 4
      3066360.98     13881049.35      3066378.79     13879324.31
      3066311.76     13878684.69      3066338.02     13878247.29
#Sta/Elev= 30
  3014.5    94.6  3334.5    94.8  3364.5    92.8  3514.5    91.7  3564.5    93.5
  3934.5      93  3984.5    91.2  4504.5    90.3  4544.5      89  4574.5    91.6
  4634.5    91.2  4654.5      90  4941.7   92.11    4967   90.93  4987.6   81.25
  4995.3   79.41  4995.6   78.01  5000.1   77.64  5004.2   78.51    5015   85.44
  5034.5   92.41  5061.1   93.76  5169.6    92.2  5199.6    89.4  5259.6    88.6
  5281.3   89.36  5382.8    91.6  5602.8    90.1  5752.8    90.7  5820.9    92.6
#Mann= 9 ,-1 , 0
  3014.5     .99       0  3934.5     .12       0  4504.5     .08       0
  4574.5     .04       0  4634.5     .08       0    4967     .04       0
  5061.1     .12       0  5281.3     .08       0  5382.8     .99       0
#XS Ineff= 2 , 0
       0                  5820.9       0      94
Permanent Ineff=
       F       F
Bank Sta=4967,5034.5
XS Rating Curve= 0
Exp/Cntr=.3,.1
