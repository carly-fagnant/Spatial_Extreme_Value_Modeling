HEC-RAS study E117_baker.prj: E117-00-00

--- E117_baker.g02 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,32811   ,49.3,49,58.8
BEGIN DESCRIPTION:
PL1_E117-00-00-PL17B - 2
Right overbank spills to road ditch that eventually spills to E115-04 as well as an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 5
      3059183.04     13880314.92      3061408.02     13878588.59
      3061500.01     13878517.13      3062943.99      13877379.3
 3063042.810695613876744.4571162
#Sta/Elev= 30
  2142.2  103.43  3422.2  100.03  3462.2  102.23  3732.2   98.33  4022.3   99.53
  4142.2   97.43  4172.2   99.73  4219.4     100  4262.2   99.43  4292.3   96.63
 4957.17    96.6 4981.57   94.57 4991.07   90.37 5001.17   88.43 5015.47   94.85
  5124.9   97.93  5364.8   93.33  5514.8   94.03  5554.9   96.53  5594.9   95.33
  5684.8   98.53  5804.8   96.03  5894.9   97.23  5994.8   95.43  6054.8   97.23
  6264.8   95.43  6604.9   97.13  6911.2   95.43  6961.2   96.93  7551.3   96.73
#Mann= 7 ,-1 , 0
  2142.2     .99       0  4219.4     .05       0 4981.57     .04       0
 5015.47     .05       0  5124.9    .026       0  5594.9     .08       0
  6604.9     .99       0
#XS Ineff= 3 ,-1
    4500 4971.83   95.83 5081.32 5687.94   96.54 5687.94  7551.2   98.48
Permanent Ineff=
       F       F       F
#Block Obstruct= 1 ,-1
    5125  5684.4   97.93
Bank Sta=4981.57,5015.47
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,32762   ,28.6,28,36.3
BEGIN DESCRIPTION:
UP RR 17a - 3
Right overbank spills to road ditch that eventually spills to E115-04 as well as an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 3
      3059222.87      13880342.6      3062995.98     13877418.51
 3063009.434051313877329.5400003
#Sta/Elev= 30
  2145.1  102.85  2315.1  101.05  2385.1  102.25  2784.8  100.05  3625.1   99.95
  3715.1   97.55  3855.1   97.65  3885.1   99.05  3925.1   97.75  4125.1   97.95
  4155.1   96.55  4175.1   99.35    4265   99.85  4305.1   95.25  4984.3   94.77
 4985.31   92.55  4992.9   88.57  5000.8   87.95  5009.8   89.04  5025.5   96.69
  5073.7   96.27    5107   97.69  5605.1   95.65  5815.1   97.85  6335.1   95.15
  6625.1   96.05  6918.7   94.45  6938.7   95.75  6978.7   94.45  7008.7   96.15
#Mann= 5 ,-1 , 0
  2145.1     .99       0    4265     .05       0  4984.3     .04       0
  5025.5     .05       0    5107     .99       0
#XS Ineff= 2 , 0
       0    4974   96.85    5028       0   96.85
Permanent Ineff=
       F       F
Bank Sta=4984.3,5025.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,32747.5 ,,,
BEGIN DESCRIPTION:
UP RR (SOUTHERN PACIFIC)
Structure ID: E117-00-00-17a
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,9,2.6,0, 36, 36, , , .95, 0, ,,,
  2134.8  2145.1  2175.1  2215.1  2225.1  2334.8  3624.8  4865.8  4895.5  4916.3
  4946.1  4964.1  4984.3 4985.31  4985.4  4985.5  4992.9  4995.3  5000.8  5003.9
  5004.6  5009.8  5014.9 5014.99  5015.1  5018.6  5025.5    5166  5884.4  5895.1
  6625.1  6655.1  6655.1  6814.4  7008.7  7009.8
   103.4  103.34  103.31  102.96  102.91   102.8     101  100.64  100.67  100.69
  100.67  100.66   100.7   100.7   100.7   100.7  100.71  100.71  100.72  100.73
  100.73  100.72  100.71  100.71  100.71   100.7  100.69  100.67    98.5   98.45
   97.32   97.32   97.32    96.9   96.14   96.14
                                                                                
                                   98.27   98.27   98.28   98.28   98.29    98.3
    98.3   98.29   98.28   98.28
                                                
  2134.8  2145.1  2175.1  2215.1  2225.1  2334.8  3624.8  4865.8  4895.5  4916.3
  4946.1  4964.1  4984.3 4985.31  4985.4  4985.5  4992.9  4995.3  5000.8  5003.9
  5004.6  5009.8  5014.9 5014.99  5015.1  5018.6  5025.5    5166  5884.4  5895.1
  6625.1  6655.1  6655.1  6814.4  7008.7  7009.8
   103.4  103.34  103.31  102.96  102.91   102.8     101  100.64  100.67  100.69
  100.67  100.66   100.7   100.7   100.7   100.7  100.71  100.71  100.72  100.73
  100.73  100.72  100.71  100.71  100.71   100.7  100.69  100.67    98.5   98.45
   97.32   97.32   97.32    96.9   96.14   96.14
                                                                                
                                   98.27   98.27   98.28   98.28   98.29    98.3
    98.3   98.29   98.28   98.28
                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4999.9, 2 ,4999.9, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   88.68   99.29
     1.2     1.2
   88.68   99.29
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,-1,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=103.25

Type RM Length L Ch R = 1 ,32734   ,31.9,34,43.8
BEGIN DESCRIPTION:
UP RR 17a - 2
Right overbank spills to road ditch that eventually spills to E115-04 as well as an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 3
      3059243.59      13880361.6      3063018.29     13877436.28
 3063032.1182761 13877344.833148
#Sta/Elev= 30
  2134.8  103.35  2315.1  101.05  2385.1  102.25  2784.8  100.05  3455.1  100.45
  3625.1   99.95  3715.1   97.55  3855.1   97.65  3885.1   99.05  3925.1   97.75
  4125.1   97.95  4155.1   96.55  4175.1   99.35    4265   99.85  4305.1   95.25
  4984.3   94.77 4985.31   92.55  4992.9   88.57  5000.8   87.95  5009.8   89.04
  5025.5   96.69    5107   97.69  5605.1   95.65  5815.1   97.85  6335.1   95.15
  6625.1   96.05  6918.7   94.45  6938.7   95.75  6978.7   94.45  7008.7   96.15
#Mann= 5 ,-1 , 0
  2134.8     .99       0    4265     .05       0  4984.3     .04       0
  5025.5     .05       0    5107     .99       0
#XS Ineff= 2 , 0
       0    4974      96    5028       0      96
Permanent Ineff=
       F       F
Bank Sta=4984.3,5025.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,32700   ,200.5,98,76.9
BEGIN DESCRIPTION:
Hempstead Highway - 3
Right overbank spills to road ditch that eventually spills to E115-04 as well as an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 2
      3059237.3813880388.0572488 3063684.370452913876978.1859843
#Sta/Elev= 30
  2101.4  104.22  2107.6  103.62  2677.6  100.92  3137.6  100.32  3417.6   99.52
  3427.6   98.92  3467.6   99.62  3607.6   99.42  3847.6   97.42  4167.6   97.42
  4207.6   99.12  4317.6   98.32  4357.6   96.52  4407.6   95.92    4630   95.15
  4760.4   94.29  4915.8   94.64  4966.4   92.77  4993.3   87.55  5004.7   87.29
  5015.7   88.57  5021.1   92.14  5030.3   93.25  5081.1   94.99    5300   95.14
  6347.6   96.32  7107.6   95.82  7477.6   96.72  7627.6   96.32  7717.6   97.62
#Mann= 5 ,-1 , 0
  2101.4     .99       0    4630     .05       0  4966.4     .05       0
  5030.3     .05       0    5300     .99       0
#XS Ineff= 2 , 0
       0    4983   96.75    5024       0   96.75
Permanent Ineff=
       F       F
Bank Sta=4966.4,5030.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 2 ,32652   ,,,
BEGIN DESCRIPTION:
HEMPSTEAD HIGHWAY
Structure ID: E117-00-00-17
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,76,2.6,0, 60, 60, , , .95, 0, ,,,
  2101.4  2107.6  2677.6  2977.6  3027.6  3137.6  3417.6  3427.6  3467.6  3527.6
  3597.6  3607.6  3697.6  3707.6  3807.6  3847.6  4007.6  4167.6  4207.6  4317.6
  4357.6  4407.6  4417.6  4437.6  4477.6  4487.6  4547.6  4567.6  4627.6  4637.6
  4760.4  4915.8 4941.49  4941.6  4966.4  4982.4  4993.3  4995.9    5010  5015.7
  5021.1  5030.3  5039.9 5040.01  5081.1  5189.7  5227.6  5237.6  5277.6  5287.6
  5299.4  5697.6  5777.6  5857.6  6347.6  7107.6  7477.6  7627.6  7687.6  7717.6
     104  103.99  102.72  101.94  101.81  101.53   100.8  100.77  100.67  100.51
  100.33   100.3  100.07  100.04   99.78   99.67   99.28   99.12   99.08   98.97
   98.93   98.88   98.87   98.85   98.81    98.8   98.74   98.72   98.66   98.65
   98.53   98.39   98.39   99.89   99.95     100  100.02  100.03  100.05  100.06
  100.06  100.08  100.09   98.59    98.6   98.44   98.25   98.21   98.01   97.96
    97.9    97.9    97.9    97.9   97.69   97.17   96.92   96.82   96.78   97.41
     104   103.4   100.7   100.5    99.9   100.1    99.3    98.7    99.4    98.9
    98.9    99.2    98.1    98.5    97.8    97.2    97.5    97.2    98.9    98.1
    96.3    95.7      96    95.5    95.9    95.3    95.6    94.9    95.1    94.4
   94.07   94.42   93.47   93.47   92.55   89.07   87.33       0       0   88.35
   91.92   93.03   93.36   93.36   94.77   94.82    94.4    94.7    94.5    94.9
   94.92    95.2    95.7    95.8    96.1    95.6    96.5    96.1    96.5    97.4
  2101.4  2107.6  2677.6  2977.6  3027.6  3137.6  3417.6  3427.6  3467.6  3527.6
  3597.6  3607.6  3697.6  3707.6  3807.6  3847.6  4007.6  4167.6  4207.6  4317.6
  4357.6  4407.6  4417.6  4437.6  4477.6  4487.6  4547.6  4567.6  4627.6  4637.6
  4760.4  4915.8 4941.49  4941.6  4966.4  4982.4  4993.3  5004.7    5010  5015.7
  5021.1  5030.3  5039.9 5040.01  5081.1  5189.7  5227.6  5237.6  5277.6  5287.6
  5299.4  5697.6  5777.6  5857.6  6347.6  7107.6  7477.6  7627.6  7687.6  7717.6
     104  103.99  102.72  101.94  101.81  101.53   100.8  100.77  100.67  100.51
  100.33   100.3  100.07  100.04   99.78   99.67   99.28   99.12   99.08   98.97
   98.93   98.88   98.87   98.85   98.81    98.8   98.74   98.72   98.66   98.65
   98.53   98.39   98.39   99.89   99.95     100  100.02  100.04  100.05  100.06
  100.06  100.08  100.09   98.59    98.6   98.44   98.25   98.21   98.01   97.96
    97.9    97.9    97.9    97.9   97.69   97.17   96.92   96.82   96.78   97.41
  100.43   99.83   97.13   96.93   96.33   96.53   95.73   95.13   95.83   95.33
   95.33   95.63   94.53   94.93   94.23   93.63   93.93   93.63   95.33   94.53
   92.73   92.13   92.43   91.93   92.33   91.73   92.03   91.33   91.53   90.83
    90.5   90.85    89.9    89.9   88.98    85.5   83.76    83.5    84.4   84.78
   88.35   89.46   89.79   89.79    91.2   91.25   90.83   91.13   90.93   91.33
   91.35   91.63   92.13   92.23   92.53   92.03   92.93   92.53   92.93   93.83
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Culvert=2,10,10,76,.015,.5,1,10,1,83.41,4998.4,83.49,4998.4,Culvert #1  , 0 ,10
Culvert Bottom n=.015
Culvert=2,10,10,76,.015,.5,1,10,1,83.51,5009,83.53,5009,Culvert #2  , 0 ,10
Culvert Bottom n=.035
BR U #Sta/Elev= 85
  2101.4     104  2107.6   103.4  2167.6   103.1  2341.4  102.36  2567.6   101.4
  2677.6   100.7  2807.6   100.5  2977.6   100.5  3027.6    99.9  3137.6   100.1
  3417.6    99.3  3427.6    98.7  3467.6    99.4  3527.6    98.9  3597.6    98.9
  3607.6    99.2  3697.6    98.1  3707.6    98.5  3807.6    97.8  3847.6    97.2
  3991.4   97.47  4007.6    97.5  4037.6    97.4  4167.6    97.2  4207.6    98.9
  4317.6    98.1  4357.6    96.3  4407.6    95.7  4417.6      96  4437.6    95.5
  4477.6    95.9  4487.6    95.3  4537.6    95.4  4547.6    95.6  4567.6    94.9
  4627.6    95.1    4630   94.93  4637.6    94.4  4760.4   94.07  4810.9    94.2
  4832.6    94.2  4862.8   94.19  4886.6   94.29  4915.8   94.42 4941.49   93.47
  4941.6   93.47 4941.71   93.46  4966.4   92.55  4982.4   89.07    4990   87.92
  4993.3   87.33  4993.4   83.41  5003.4   83.41    5004   83.51    5014   83.51
  5015.7   88.35  5021.1   91.92  5030.3   93.03 5039.79   93.36  5039.9   93.36
 5040.01   93.36    5049   93.67  5081.1   94.77  5103.9   94.82  5134.7   94.89
  5159.6   94.86  5189.7   94.82  5227.6    94.4  5237.6    94.7  5277.6    94.5
  5287.6    94.9  5299.4   94.92    5300   94.92  5437.6    95.1  5697.6    95.2
  5777.6    95.7  5857.6    95.8  6007.6    95.9  6029.4   95.91  6347.6    96.1
  7107.6    95.6  7477.6    96.5  7627.6    96.1  7687.6    96.5  7717.6    97.4
BR U #Mann= 5
  2101.4     .99    4630     .05  4966.4     .05  5030.3     .05    5300     .99
BR U Banks=4966.4,5030.3
BR D #Sta/Elev= 84
  2101.4     104  2107.6   103.4  2167.6   103.1  2341.4  102.36  2567.6   101.4
  2677.6   100.7  2807.6   100.5  2977.6   100.5  3027.6    99.9  3137.6   100.1
  3417.6    99.3  3427.6    98.7  3467.6    99.4  3527.6    98.9  3597.6    98.9
  3607.6    99.2  3697.6    98.1  3707.6    98.5  3807.6    97.8  3847.6    97.2
  3991.4   97.47  4007.6    97.5  4037.6    97.4  4167.6    97.2  4207.6    98.9
  4317.6    98.1  4357.6    96.3  4407.6    95.7  4417.6      96  4437.6    95.5
  4477.6    95.9  4487.6    95.3  4537.6    95.4  4547.6    95.6  4567.6    94.9
  4627.6    95.1    4630   94.93  4637.6    94.4  4760.4   94.07  4810.9    94.2
  4832.6    94.2  4862.8   94.19  4886.6   94.29  4915.8   94.42 4941.49   93.47
  4941.6   93.47 4941.71   93.46  4966.4   92.55  4982.4    85.5    4990   84.35
  4993.3   83.76  4995.9    83.7  5004.7    83.5    5010    84.4  5015.7   84.78
  5021.1   88.35  5030.3   93.03 5039.79   93.36  5039.9   93.36 5040.01   93.36
    5049   93.67  5081.1   94.77  5103.9   94.82  5134.7   94.89  5159.6   94.86
  5189.7   94.82  5227.6    94.4  5237.6    94.7  5277.6    94.5  5287.6    94.9
  5299.4   94.92    5300   94.92  5437.6    95.1  5697.6    95.2  5777.6    95.7
  5857.6    95.8  6007.6    95.9  6029.4   95.91  6347.6    96.1  7107.6    95.6
  7477.6    96.5  7627.6    96.1  7687.6    96.5  7717.6    97.4
BR D #Mann= 5
  2101.4     .99    4630     .05  4966.4     .05  5030.3     .05    5300     .99
BR D Banks=4966.4,5030.3
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=104.22

Type RM Length L Ch R = 1 ,32602   ,23.1,14,18.5
BEGIN DESCRIPTION:
Hempstead Highway - 2
Right overbank spills to road ditch that eventually spills to E115-04 as well as an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 4
      3060248.2513880996.8793134       3061390.2     13878915.62
      3061762.52     13878524.51 3063729.972676813877044.1044992
#Sta/Elev= 30
  2341.4   98.79  2567.6  101.62  3417.6   99.52  3427.6   98.92  3467.6   99.62
  3607.6   99.42  3847.6   97.42  4167.6   97.42  4207.6   99.12  4317.6   98.32
  4357.6   96.52  4407.6   95.92    4630   95.15  4637.6   94.62  4760.4   94.29
  4915.8   94.64  4966.4   92.77  4982.4    85.5  4993.3   83.76  5004.7    83.5
  5015.7   84.78  5030.3   93.25  5081.1   94.99  5227.6   94.62    5300   95.14
  6347.6   96.32  7107.6   95.82  7477.6   96.72  7627.6   96.32  7717.6   97.62
#Mann= 5 ,-1 , 0
  2341.4     .99       0    4630     .05       0  4966.4     .05       0
  5030.3     .05       0    5300     .99       0
#XS Ineff= 2 , 0
       0    4983   95.25    5024       0   95.25
Permanent Ineff=
       F       F
Bank Sta=4966.4,5030.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,32588   ,2398.2,2632,2504.4
BEGIN DESCRIPTION:
Concord Park - 3
END DESCRIPTION:
XS GIS Cut Line= 4
      3060246.24     13881025.69      3061397.15     13878928.08
      3061770.21     13878536.21 3062777.064342413877778.6027286
#Sta/Elev= 30
  2320.6   102.5  2360.6   102.4  2430.6    99.9  2530.6    99.4  3800.6    99.4
  4340.6    97.1  4360.6    95.8  4410.6    97.2  4430.6      97  4470.6    94.1
  4490.6    95.6    4590   97.09  4934.4   96.34  4966.8   92.78  4984.5   84.67
  5002.8    83.5  5009.1   84.67    5012   84.91  5029.5   93.82  5056.6   96.73
  5253.2      96    5350   97.34  5404.3    95.9  5594.3    96.1  5634.3    97.3
  5684.3    96.4  5924.3    97.6  6004.3    96.3  6174.3    96.2  6514.3    97.7
#Mann= 4 ,-1 , 0
  2320.6     .99       0    4590     .05       0  5009.1     .05       0
    5350     .99       0
#XS Ineff= 2 , 0
       0 4975.75    95.8    5017       0   96.74
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
  5365.6 5639.93   97.09
Bank Sta=4934.4,5056.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 2 ,31272   ,,,
BEGIN DESCRIPTION:
Long Culvert at Concord Park Rd.  As known as HWY 290/Hempstead Hwy
Structure ID: E117-00-00-16a
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,2612,3,0, 60, 60, , , .95, 0, ,,,
  2320.6  2517.1  3220.6  3800.6  4340.6  4360.6  4410.6  4460.6  4590.6  4713.2
  4926.6  5007.4  5056.6  5253.2  5344.3  5404.3  5594.3  5634.3  5684.3  5734.3
  5924.3  6004.3  6174.3  6384.3  6494.3  6514.3  6846.6  6936.6  7094.3  7274.3
  7414.3  7474.3  7494.3  7634.3  7664.3  7944.3  7984.3  8041.6  8081.6  8191.6
  8221.6  8301.6  8331.6  8351.6  8381.6  8411.6  8491.6  8531.6  8561.6  8651.6
  8686.6  8736.6  9096.6  9146.6  9401.6  9441.6  9536.6  9721.6  9761.6  9892.9
   102.5   100.6   98.61   99.41   97.11   95.81   97.21   95.45   97.11   96.13
    96.7   97.86   96.74   96.05   97.41   95.95   96.11   97.31   96.41   97.41
   97.61   96.31   96.27   97.51   96.81   97.71    95.4    96.8   95.51   96.01
    94.3   95.41   94.33   94.59   95.61   95.31   93.97   95.31   93.94   94.01
   95.21   93.85   95.11   94.41   95.21   93.81   95.21   93.76   94.91   95.21
    93.7    93.3    95.7    94.7   95.91    94.7    95.7    94.4    95.5      95
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
  2320.6  2517.1  3220.6  3800.6  4340.6  4360.6  4410.6  4460.6  4590.6  4713.2
  4926.6  5007.4  5056.6  5253.2  5344.3  5404.3  5594.3  5634.3  5684.3  5734.3
  5924.3  6004.3  6174.3  6384.3  6494.3  6514.3  6846.6  6936.6  7094.3  7274.3
  7414.3  7474.3  7494.3  7634.3  7664.3  7944.3  7984.3  8041.6  8081.6  8191.6
  8221.6  8301.6  8331.6  8351.6  8381.6  8411.6  8491.6  8531.6  8561.6  8651.6
  8686.6  8736.6  9096.6  9146.6  9401.6  9441.6  9536.6  9721.6  9761.6  9892.9
   102.5   100.6   98.61   99.41   97.11   95.81   97.21   95.45   97.11   96.13
    96.7   97.86   96.74   96.05   97.41   95.95   96.11   97.31   96.41   97.41
   97.61   96.31   96.27   97.51   96.81   97.71    95.4    96.8   95.51   96.01
    94.3   95.41   94.33   94.59   95.61   95.31   93.97   95.31   93.94   94.01
   95.21   93.85   95.11   94.41   95.21   93.81   95.21   93.76   94.91   95.21
    93.7    93.3    95.7    94.7   95.91    94.7    95.7    94.4    95.5      95
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Culvert=2,10,14,2612,.02,.4,1,8,1,81.9,4982.8,78.59,4982.8,Culvert #1  , 0 ,10
Culvert Bottom n=.02
Culvert=2,6,12,2612,.02,.4,1,8,1,81.92,4996.4,79.58,4996.4,Culvert #2  , 0 ,10
Culvert Bottom n=.02
Culvert=2,10,14,2612,.015,.4,1,8,1,81.99,5010,78.62,5010,Culvert #3  , 0 ,10
Culvert Bottom n=.015
BR D #Sta/Elev= 76
  3136.8   113.2  3176.8   113.5  3196.8   111.1    3249  100.57  3256.8      99
  3266.8    97.2    3269   96.91  3276.8    95.9  3286.8      95    3319   95.39
  3336.8    95.6    3349   95.42  3356.8    95.3    3379   96.13  3396.8    96.8
    3619   96.08  3706.8    95.8    3719   95.78    3779   95.68    3809   95.63
  3826.8    95.6  3836.8    95.9  3846.8    96.9  4076.8    95.3  4196.8    95.6
  4226.8    94.7  4276.8    95.1  4288.8   94.86  4306.8    94.5  4359.8    94.8
  4756.8   92.45  4808.8   92.65  4812.1   92.66  4814.9   92.67  4868.8   92.67
  4923.9   92.68  4932.9   92.68  4940.1   92.68  4950.3   89.84 4950.37   89.82
 4950.48   89.79 4950.59   89.76 4950.71   89.72  4950.8    89.7  4975.8   82.73
  4975.8   78.59    5017   78.62    5017   80.92  5019.7   81.16  5032.3    84.3
 5052.59   89.36  5052.7   89.39 5052.81   89.42 5052.89   89.44    5053   89.47
  5053.1   89.49  5065.2   92.51  5071.2   92.52  5094.4   92.57  5149.6   92.69
    5165   92.72  5209.8   92.53  5289.8    93.1    5290    93.1  5839.8    92.9
  5869.8    92.1  5909.8    93.1  5949.8    91.7  5967.5   91.61  5969.8    91.6
  6013.7    92.7  6063.7    91.6  6094.9   91.84  6116.6      92    6184  106.87
  6184.6     107
BR D #Mann= 7
  3136.8     .99  4808.8     .05  4932.9     .04  4940.1    .015  5065.2     .04
  5071.2     .05  5289.8     .99
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=102.5

Type RM Length L Ch R = 1 ,29956   ,22.2,27,20.6
BEGIN DESCRIPTION:
Concord Park - 2
END DESCRIPTION:
XS GIS Cut Line= 4
      3062073.81     13879897.81      3063226.95     13879490.38
      3064726.46     13878792.61      3064896.37     13878811.29
#Sta/Elev= 30
  3136.8   113.2  3176.8   113.5  3196.8   111.1  3266.8    97.2  3286.8      95
  3356.8    95.3  3396.8    96.8  3826.8    95.6  3846.8    96.9  4076.8    95.3
  4196.8    95.6  4808.8   92.65  4932.9   92.68  4940.1   92.68  4980.9   81.31
  4986.5   80.61  4989.4   78.68  5007.8   79.19  5019.7   81.16  5065.2   92.51
  5071.2   92.52  5289.8    93.1  5839.8    92.9  5869.8    92.1  5909.8    93.1
  5949.8    91.7  6013.7    92.7  6063.7    91.6  6116.6      92  6184.6     107
#Mann= 7 ,-1 , 0
  3136.8     .99       0  4808.8     .05       0  4932.9     .04       0
  4940.1    .015       0  5065.2     .04       0  5071.2     .05       0
  5289.8     .99       0
#XS Ineff= 2 , 0
       0    4966   92.25    5027       0   92.25
Permanent Ineff=
       F       F
Bank Sta=4940.1,5065.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,29929   ,59.5,77,61.8
BEGIN DESCRIPTION:
US 290 E.B. Access Rd - 3
END DESCRIPTION:
XS GIS Cut Line= 5
      3062090.7713879911.8759116      3062094.64     13879910.51
        3063248.       13879503.      3064746.46     13878805.71
 3064908.618439713878823.5405002
#Sta/Elev= 30
  3132.7   113.2  3176.8   113.5  3196.8   111.1  3266.8    97.2  3286.8      95
  3356.8    95.3  3396.8    96.8  3826.8    95.6  3846.8    96.9  4076.8    95.3
  4196.8    95.6  4808.8   92.65  4932.9   92.68  4940.1   92.68  4980.9   81.31
  4986.5   80.61  4989.4   78.68  5007.8   79.19  5019.7   81.16  5065.2   92.51
  5071.2   92.52  5289.8    93.1  5839.8    92.9  5869.8    92.1  5909.8    93.1
  5949.8    91.7  6013.7    92.7  6063.7    91.6  6116.6      92  6178.2  106.87
#Mann= 7 ,-1 , 0
  3132.7     .99       0  4808.8     .05       0  4932.9     .04       0
  4940.1    .015       0  5065.2     .04       0  5071.2     .05       0
  5289.8     .99       0
#XS Ineff= 2 , 0
       0 4950.46   92.68 5053.15       0   93.14
Permanent Ineff=
       F       F
Bank Sta=4940.1,5065.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,29890.5 ,,,
BEGIN DESCRIPTION:
US 290 E.B. ACCES RD; Don't need to skew-stream straightens out
Structure ID: E117-00-00-16aa
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,57,2.6,0, 56, 56, , , .95, 0, ,,,
  3136.8  3176.8  3196.8  3256.8  3266.8  3276.8  3286.8  3336.8    3349  3356.8
    3379  3396.8    3619  3706.8    3719    3779    3809  3826.8  3836.8  3846.8
  4076.8  4196.8  4226.8  4276.8  4306.8  4359.8  4756.8  4812.1  4923.9  4940.1
 4950.37 4950.48 4950.71  4950.8  5052.7 5052.81 5052.89    5053  5065.2  5094.4
  5149.6    5165  5209.8  5289.8  5839.8  5869.8  5909.8  5949.8  5967.5  5969.8
  6013.7  6063.7  6094.9  6116.6    6184  6184.6
   113.2   113.5   111.1   99.01   97.21   95.91   95.34   95.72    95.8   96.01
    96.6   96.81   96.09   95.88      96   95.69    96.4    96.3   96.24   96.91
   95.31   95.61   94.71   95.11   94.51   94.81    92.8   92.67   92.78   92.93
   93.03   95.73   95.73   95.73   95.78   93.08   93.08   93.08   93.01   92.84
    92.7   92.73   92.61   93.11   92.91   92.11   93.11   91.72    91.7   91.71
   92.71   92.08    92.2    95.8     107     107
   113.2   113.5   111.1      99    97.2    95.9      95    95.6   95.42    95.3
   96.13    96.8   96.08    95.8   95.78   95.68   95.63    95.6    95.9    96.9
    95.3    95.6    94.7    95.1    94.5    94.8   92.45   92.66   92.68   92.68
   89.82   89.79   89.72   90.33   90.38   90.38   90.38   89.47   92.51   92.57
   92.69   92.72   92.53    93.1    92.9    92.1    93.1    91.7   91.61    91.6
    92.7    91.6   91.84      92  106.87     107
  3136.8  3176.8  3196.8  3256.8  3266.8  3276.8  3286.8  3336.8    3349  3356.8
    3379  3396.8    3619  3706.8    3719    3779    3809  3826.8  3836.8  3846.8
  4076.8  4196.8  4226.8  4276.8  4306.8  4359.8  4756.8  4812.1  4923.9  4940.1
 4950.37 4950.48 4950.71  4950.8  5052.7 5052.81 5052.89    5053  5065.2  5094.4
  5149.6    5165  5209.8  5289.8  5839.8  5869.8  5909.8  5949.8  5967.5  5969.8
  6013.7  6063.7  6094.9  6116.6    6184  6184.6
   113.2   113.5   111.1   99.01   97.21   95.91   95.34   95.72    95.8   96.01
    96.6   96.81   96.09   95.88      96   95.69    96.4    96.3   96.24   96.91
   95.31   95.61   94.71   95.11   94.51   94.81    92.8   92.67   92.78   92.93
   93.03   95.73   95.73   95.73   95.78   93.08   93.08   93.08   93.01   92.84
    92.7   92.73   92.61   93.11   92.91   92.11   93.11   91.72    91.7   91.71
   92.71   92.08    92.2    95.8     107     107
   113.2   113.5   111.1      99    97.2    95.9      95    95.6   95.42    95.3
   96.13    96.8   96.08    95.8   95.78   95.68   95.63    95.6    95.9    96.9
    95.3    95.6    94.7    95.1    94.5    94.8   92.45   92.66   92.68   92.68
   89.82   89.79   89.72   90.33   90.38   90.38   90.38   89.47   92.51   92.57
   92.69   92.72   92.53    93.1    92.9    92.1    93.1    91.7   91.61    91.6
    92.7    91.6   91.84      92  106.87     107
Pier Skew, UpSta & Num, DnSta & Num=  ,4980.9, 2 ,4980.9, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   80.21   91.31
     1.5     1.5
   80.21   91.31
Pier Skew, UpSta & Num, DnSta & Num=  ,5019.7, 2 ,5019.7, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   80.09   91.33
     1.5     1.5
   80.09   91.33
Abutment Skew #Up #Dn= , 2 , 2
  4950.6  4986.5
   90.33   80.61
  4950.6  4986.5
   90.33   80.61
Abutment Skew #Up #Dn= , 2 , 2
  5013.5 5053.09
   80.62   90.38
  5013.5 5053.09
   80.62   90.38
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 81
  3136.8   113.2  3176.8   113.5  3196.8   111.1    3249  100.57  3256.8      99
  3266.8    97.2    3269   96.91  3276.8    95.9  3286.8      95    3319   95.39
  3336.8    95.6    3349   95.42  3356.8    95.3    3379   96.13  3396.8    96.8
    3619   96.08  3706.8    95.8    3719   95.78    3779   95.68    3809   95.63
  3826.8    95.6  3836.8    95.9  3846.8    96.9  4076.8    95.3  4196.8    95.6
  4226.8    94.7  4276.8    95.1  4288.8   94.86  4306.8    94.5  4359.8    94.8
  4756.8   92.45  4808.8   92.65  4812.1   92.66  4814.9   92.67  4868.8   92.67
  4923.9   92.68  4932.9   92.68  4940.1   92.68  4950.3   89.84 4950.37   89.82
 4950.48   89.79 4950.59   89.76 4950.71   89.72  4950.8    89.7  4978.9   81.87
  4980.9   81.31  4986.3   80.61  4986.4   80.61  4986.5   80.61  4989.4   78.68
  5007.8   79.19  5013.4   80.61  5013.5   80.62  5019.7   81.16  5032.3    84.3
 5052.59   89.36  5052.7   89.39 5052.81   89.42 5052.89   89.44    5053   89.47
  5053.1   89.49  5065.2   92.51  5071.2   92.52  5094.4   92.57  5149.6   92.69
    5165   92.72  5209.8   92.53  5289.8    93.1    5290    93.1  5839.8    92.9
  5869.8    92.1  5909.8    93.1  5949.8    91.7  5967.5   91.61  5969.8    91.6
  6013.7    92.7  6063.7    91.6  6094.9   91.84  6116.6      92    6184  106.87
  6184.6     107
BR U #Mann= 7
  3136.8     .99  4808.8     .05  4932.9     .04  4940.1    .015  5065.2     .04
  5071.2     .05  5289.8     .99
BR U Banks=4940.1,5065.2
BR D #Sta/Elev= 81
  3136.8   113.2  3176.8   113.5  3196.8   111.1    3249  100.57  3256.8      99
  3266.8    97.2    3269   96.91  3276.8    95.9  3286.8      95    3319   95.39
  3336.8    95.6    3349   95.42  3356.8    95.3    3379   96.13  3396.8    96.8
    3619   96.08  3706.8    95.8    3719   95.78    3779   95.68    3809   95.63
  3826.8    95.6  3836.8    95.9  3846.8    96.9  4076.8    95.3  4196.8    95.6
  4226.8    94.7  4276.8    95.1  4288.8   94.86  4306.8    94.5  4359.8    94.8
  4756.8   92.45  4808.8   92.65  4812.1   92.66  4814.9   92.67  4868.8   92.67
  4923.9   92.68  4932.9   92.68  4940.1   92.68  4950.3   89.84 4950.37   89.82
 4950.48   89.79 4950.59   89.76 4950.71   89.72  4950.8    89.7  4978.9   81.87
  4980.9   81.31  4986.3   80.61  4986.4   80.61  4986.5   80.61  4989.4   78.68
  5007.8   79.19  5013.4   80.61  5013.5   80.62  5019.7   81.16  5032.3    84.3
 5052.59   89.36  5052.7   89.39 5052.81   89.42 5052.89   89.44    5053   89.47
  5053.1   89.49  5065.2   92.51  5071.2   92.52  5094.4   92.57  5149.6   92.69
    5165   92.72  5209.8   92.53  5289.8    93.1    5290    93.1  5839.8    92.9
  5869.8    92.1  5909.8    93.1  5949.8    91.7  5967.5   91.61  5969.8    91.6
  6013.7    92.7  6063.7    91.6  6094.9   91.84  6116.6      92    6184  106.87
  6184.6     107
BR D #Mann= 7
  3136.8     .99  4868.8     .05  4932.9     .04  4940.1    .015  5065.2     .04
  5071.2     .05    5165     .99
BR D Banks=4940.1,5065.2
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=113.5

Type RM Length L Ch R = 1 ,29852   ,28.8,47,28.8
BEGIN DESCRIPTION:
US 290 E.B. Access Rd - 2
Right overbank spills to an unstudied ditch that flows into E117-00-00
END DESCRIPTION:
XS GIS Cut Line= 4
      3062174.1413879957.7020064      3063222.58      13879581.6
      3064007.68     13879213.23 3064826.334847513878849.5146684
#Sta/Elev= 30
  3136.8  113.29  3176.8  113.59  3196.8  111.19  3266.8   97.29  3286.8   95.09
  3356.8   95.39  3396.8   96.89  3826.8   95.69  3846.8   96.99  4076.8   95.39
  4196.8   95.69  4226.8   94.79  4756.8   92.54  4868.8   92.76  4932.9   92.77
  4940.1   92.77  4980.9    81.4  4986.5    80.7  4989.4   78.77  5007.8   79.28
  5013.4    80.7  5019.7   81.25  5065.2    92.6  5071.2   92.61    5165   92.81
  5839.8   92.99  5869.8   92.19  5909.8   93.19  5969.8   91.69  6013.7   92.79
#Mann= 7 ,-1 , 0
  3136.8     .99       0  4868.8     .05       0  4932.9     .04       0
  4940.1    .015       0  5065.2     .04       0  5071.2     .05       0
    5165     .99       0
#XS Ineff= 2 , 0
       0 4950.46    91.5 5053.15       0    91.5
Permanent Ineff=
       F       F
Bank Sta=4940.1,5065.2
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,29805   ,125,254,127
BEGIN DESCRIPTION:
US 290 - 3
Low points on left and right overbank are from roadway ditches
END DESCRIPTION:
XS GIS Cut Line= 4
  3062256.83253813879955.4339547      3063262.29     13879594.75
      3064047.55      13879226.3 3064803.554996913878890.4078955
#Sta/Elev= 30
2245.417  108.512287.844   97.012294.915   95.712301.986   95.212379.768   95.11
 2393.91   95.912415.123   97.612436.336   96.113006.123   94.213140.472   93.21
3154.615   93.81 3184.95    93.53329.554  100.943398.214  101.93  3427.7  102.36
3458.035   95.963515.169    84.43527.614    79.33541.826    79.83546.777   80.49
3596.911   84.413606.457   94.073659.702  108.183746.464  109.653831.458   96.91
3902.169   94.91 3909.24   94.013916.311   93.614177.939   91.714199.083   91.91
#Mann= 4 ,-1 , 0
2245.417     .99       03398.214     .04       0  3427.7    .015       0
3659.702     .99       0
#XS Ineff= 2 , 0
       03420.629   92.813666.773       0      98
Permanent Ineff=
       F       F
Bank Sta=3427.7,3659.702
XS Rating Curve= 0
Skew Angle= 45
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,29680   ,,,
BEGIN DESCRIPTION:
US 290
Structure ID: E117-00-00-16
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,230,2.6,45, 63, 63, , , .95, 0, ,,,
 3184.95 3234.45  3281.93296.041 3312.23 3323.33 3329.55  3368.8 3369.293398.209
 3407.41  3427.7 3444.67 3450.47 3450.55  3450.6 3450.68 3450.75 3450.83 3458.04
3482.429 3515.17  3520.43524.149 3524.22 3524.29 3527.61 3541.83 3546.71 3546.78
 3558.44 3595.43 3596.91 3606.46 3632.83 3641.01 3641.083641.159 3641.24 3641.32
  3659.73677.309 3714.573746.459 3753.61 3753.68 3764.78 3781.96 3800.13 3814.28
3831.459 3835.49 3849.63 3899.133902.169 3909.24 3916.314177.939 4181.62 4197.88
 4199.08 4262.72 4262.94
    93.6   93.09   92.81   92.99   96.89  100.23  101.04  101.61   102.2  103.04
  103.31  103.85   104.3  104.36  104.36  104.36  104.36  107.06  107.06  107.28
  108.02  108.82  108.95  109.04  109.04  109.05  109.13  109.47  109.59  109.59
  109.88  110.58  110.61  110.79  111.28  111.34  111.34  108.64  108.64  108.64
  108.99  109.33  109.94   110.4  110.51  110.51   102.6  102.07   101.5    99.8
   97.01    96.9    96.5    95.1   95.01   94.11   93.71   92.01      92      95
   95.22  107.01     107
                                                                                
                                   97.63   97.62   99.16   99.16   99.16   99.38
  100.12  100.92  101.05  101.14  101.14  101.15  101.23  101.57  101.69  101.69
  101.98  102.68  102.71  102.89  103.38  103.44  103.44  103.44  103.44
                                                                                
                                                                                
                        
 3184.95 3234.45  3281.93296.041 3312.23 3323.33 3329.55  3368.8 3369.293398.209
 3407.41  3427.7 3444.67 3450.47 3450.55  3450.6 3450.68 3450.75 3450.83 3458.04
3482.429 3515.17  3520.43524.149 3524.22 3524.29 3527.61 3541.83 3546.71 3546.78
 3558.44 3595.43 3596.91 3606.46 3632.83 3641.01 3641.083641.159 3641.24 3641.32
  3659.73677.309 3714.573746.459 3753.61 3753.68 3764.78 3781.96 3800.13 3814.28
3831.459 3835.49 3849.63 3899.133902.169 3909.24 3916.314177.939 4181.62 4197.88
 4199.08 4262.72 4262.94
    93.6   93.09   92.81   92.99   96.89  100.23  101.04  101.61   102.2  103.04
  103.31  103.85   104.3  104.36  104.36  104.36  104.36  107.06  107.06  107.28
  108.02  108.82  108.95  109.04  109.04  109.05  109.13  109.47  109.59  109.59
  109.88  110.58  110.61  110.79  111.28  111.34  111.34  108.64  108.64  108.64
  108.99  109.33  109.94   110.4  110.51  110.51   102.6  102.07   101.5    99.8
   97.01    96.9    96.5    95.1   95.01   94.11   93.71   92.01      92      95
   95.22  107.01     107
                                                                                
                                   97.63   97.62   99.16   99.16   99.16   99.38
  100.12  100.92  101.05  101.14  101.14  101.15  101.23  101.57  101.69  101.69
  101.98  102.68  102.71  102.89  103.38  103.44  103.44  103.44  103.44
                                                                                
                                                                                
                        
Pier Skew, UpSta & Num, DnSta & Num=  ,3515.24, 2 ,3515.24, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   83.24  101.93
     1.5     1.5
    83.2  101.89
Pier Skew, UpSta & Num, DnSta & Num=  ,3596.911, 2 ,3596.911, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   83.46  103.72
     1.5     1.5
   83.42  103.68
Abutment Skew #Up #Dn= , 2 , 2
 3450.54 3524.22
   99.16    80.7
 3450.54 3524.22
   99.12   80.66
Abutment Skew #Up #Dn= , 2 , 2
3546.7773641.381
   80.58  103.44
3546.7773641.381
   80.54   103.4
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=109.65

Type RM Length L Ch R = 1 ,29551   ,31.9,51,39.4
BEGIN DESCRIPTION:
US 290 - 2
END DESCRIPTION:
XS GIS Cut Line= 4
 3062681.018095213880272.8020456      3063328.58     13879700.42
      3064316.16     13879241.48  3064660.08639313879018.7224468
#Sta/Elev= 29
2245.417  108.562287.844   97.062294.915   95.762301.986   95.262379.768   95.16
 2393.91   95.962415.123   97.662436.336   96.16 2655.54   95.563006.123   94.26
3140.472   93.263154.615   93.86 3184.95   93.553329.554  100.99  3427.7  102.41
3458.035   96.013515.169   84.453524.291   80.613527.614   79.353541.826   79.85
3546.777   80.543596.911   84.463606.457   94.123659.702  108.233746.464   109.7
3831.458   96.963902.169   94.96 3909.24   94.063916.311   93.66
#Mann= 3 ,-1 , 0
2245.417     .99       0  3427.7    .015       03659.702     .99       0
#XS Ineff= 2 , 0
       03422.984   92.813664.418       0      98
Permanent Ineff=
       F       F
Bank Sta=3427.7,3659.702
XS Rating Curve= 0
Skew Angle= 45
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,29500   ,130.1,84,88
BEGIN DESCRIPTION:
US 290 W.B. Access Rd - 3
END DESCRIPTION:
XS GIS Cut Line= 4
      3062613.55      13880386.4       3063373.4     13879714.76
      3064360.64     13879255.98      3064898.07     13878907.89
#Sta/Elev= 30
2135.462   109.82181.424   108.52195.566   105.3 2216.78    98.72223.851    97.3
2273.348    94.52322.846    95.42336.988    94.62372.343    96.42584.475    94.4
2856.641    94.9 2920.28    93.93203.123    92.43224.335    94.23259.691    94.1
3280.905    93.23430.811   92.583491.835   92.463525.776   79.383544.656   79.35
3548.827   80.593550.454   79.973566.081   92.993582.486   95.553672.005   97.24
3686.289  101.493725.675    92.93999.324    91.94060.065  103.394075.127     107
#Mann= 5 ,-1 , 0
2135.462     .99       03224.335     .08       03430.811     .04       0
3491.835    .015       03566.081     .05       0
#XS Ineff= 2 , 0
       0 3501.49   92.45 3564.16       0   94.04
Permanent Ineff=
       F       F
Bank Sta=3491.835,3566.081
XS Rating Curve= 0
Skew Angle= 45
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,29462   ,,,
BEGIN DESCRIPTION:
ACCES ROAD HWY 290
Structure ID: E117-00-00-15
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,56,2.6,45, 27, 27, , , .95, 0, ,,,
 3366.75  3404.3 3430.81 3443.89  3485.9 3491.84 3501.38 3501.46 3501.52 3501.59
 3501.66 3501.74 3522.17 3522.24 3525.78 3528.25 3544.66 3548.76 3548.83 3550.45
    3564 3566.08 3570.95 3571.03 3571.17 3571.24 3571.32
    92.7   92.64   92.59   92.56   92.68   92.68   92.69   92.69   92.69   92.69
   96.09   96.09   96.24   96.24   96.27   96.29   96.25   96.24   96.24   96.24
    96.2    96.2   96.19   96.19   96.19   96.19   93.82
    92.7   92.63   92.58   92.55   92.47   92.46   88.73    88.7   91.09   91.09
   91.09   91.09   91.24   91.24   91.27   91.29   91.25   91.24   91.24   91.24
   91.24   92.99   93.75   93.76   93.78    93.8   93.81
 3366.75  3404.3 3430.81 3443.89  3485.9 3491.84 3501.38 3501.46 3501.52 3501.59
 3501.66 3501.74 3522.17 3522.24 3525.78 3528.25 3544.66 3548.76 3548.83 3550.45
    3564 3566.08 3570.95 3571.03 3571.17 3571.24 3571.32
    92.7   92.64   92.59   92.56   92.68   92.68   92.69   92.69   92.69   92.69
   96.09   96.09   96.24   96.24   96.27   96.29   96.25   96.24   96.24   96.24
    96.2    96.2   96.19   96.19   96.19   96.19   93.82
    92.7   92.63   92.58   92.55   92.47   92.46   88.73    88.7   91.09   91.09
   91.09   91.09   91.24   91.24   91.27   91.29   91.25   91.24   91.24   91.24
   91.24
Pier Skew, UpSta & Num, DnSta & Num=  ,3526.271, 2 ,3526.271, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   78.38   92.28
     1.5     1.5
   79.28   93.18
Pier Skew, UpSta & Num, DnSta & Num=  ,3550.454, 2 ,3550.454, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   79.17    92.3
     1.5     1.5
   80.07    93.2
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR D #Sta/Elev= 74
 2129.52   109.8 2171.95  108.74 2179.02  108.56 2181.42   108.5 2195.57   105.3
 2200.23  103.78  2207.3  101.48 2209.71   100.7 2214.38   99.38 2216.78    98.7
 2223.85    97.3 2230.92    96.5  2256.8   95.28 2273.35    94.5 2299.23   94.97
 2320.44   95.36 2322.85    95.4 2336.99    94.6 2341.66    94.8 2344.06    94.9
 2351.13    95.8 2372.34    96.4 2584.48    94.4 2596.21   94.52 2641.04      95
 2758.85   94.95 2846.18    94.9 2856.64    94.9 2877.85    94.5  2888.6   94.35
 2909.82   94.05 2920.28    93.92934.419    94.2 2934.49    94.2 3185.59   92.52
 3203.12    92.4 3224.34    94.23259.689    94.1 3280.91    93.2 3295.05    91.6
 3309.19    91.2 3316.26    90.73330.399    90.4 3334.08   90.143351.621    88.9
 3355.29   88.95 3365.76    89.1 3366.75    92.7  3404.3   92.63 3430.81   92.58
 3443.89   92.55  3485.9   92.47 3491.84   92.46 3501.38   88.73 3501.46    88.7
 3501.52   88.67 3501.59   88.65 3501.66   88.62 3501.74   88.59 3522.17    80.6
 3522.24   80.57 3525.78   79.38 3528.25   79.38 3544.66   79.35 3548.76   80.57
 3548.83   80.59 3550.45   79.97 3564.69   92.01 3602.44   92.983832.519   92.51
 3980.16   91.97 3999.33    91.9 4060.07  103.39 4079.16     107
BR D #Mann= 5
 2129.52     .99 2934.49     .08 3430.81     .04 3491.84    .015 3602.44     .05
BR D Banks=3491.84,
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=109.8

Type RM Length L Ch R = 1 ,29416   ,960,322,273.6
BEGIN DESCRIPTION:
US 290 W.B. Access Rd - 2
END DESCRIPTION:
XS GIS Cut Line= 4
      3062689.78      13880412.5      3063449.09     13879741.35
      3064435.99     13879282.72      3064973.71     13878934.45
#Sta/Elev= 30
2132.351   109.82181.424   108.52195.566   105.3 2216.78    98.72223.851    97.3
2230.922    96.52273.348    94.52322.846    95.42336.988    94.6 2351.13    95.8
2372.343    96.42584.475    94.42641.044      952856.641    94.9 2920.28    93.9
3203.123    92.43224.335    94.23259.691    94.13280.905    93.23430.811   92.58
3491.835   92.463525.776   79.383544.656   79.353548.827   80.593550.454   79.97
 3564.69   92.01 3602.44   92.983999.324    91.94060.065  103.39 4071.45     107
#Mann= 4 ,-1 , 0
2132.351     .99       03224.335     .08       03430.811     .04       0
 3602.44     .05       0
#XS Ineff= 2 , 0
       0 3501.49   91.31 3564.16       0   91.31
Permanent Ineff=
       F       F
Bank Sta=3491.835,3564.69
XS Rating Curve= 0
Skew Angle= 45
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,29094   ,193.4,197,191.8
BEGIN DESCRIPTION:
Gessner - 3
END DESCRIPTION:
XS GIS Cut Line= 3
      3064240.65     13882141.58      3064658.95      13879298.9
       3065006.5     13878931.65
#Sta/Elev= 30
  2195.2   97.32  2355.2   96.32  2385.2   98.02  2415.2   96.82  2485.2   98.52
  2795.2   95.72  3495.2   94.52  3515.2   95.72  3785.2   95.02  3805.2   93.72
  3865.2   96.12  3915.2   93.42  3955.2   95.02  4105.2   95.62  4415.2   94.22
  4455.2   95.52  4635.1   93.32  4665.2   94.82  4954.3   94.37  4961.6   94.38
  4985.7   82.38    4996   79.42  5007.7    80.5  5030.3   90.84  5068.6    92.6
  5088.9   91.59  5158.5   93.02  5208.5   91.42  5452.1   91.52  5574.1  107.02
#Mann= 4 ,-1 , 0
  2195.2     .99       0  4954.3     .04       0  4961.6    .015       0
  5030.3     .05       0
#XS Ineff= 2 , 0
       0    4959    93.4    5038       0    93.1
Permanent Ineff=
       F       F
Bank Sta=4961.6,5030.3
XS Rating Curve= 0
Exp/Cntr=.5,.3
