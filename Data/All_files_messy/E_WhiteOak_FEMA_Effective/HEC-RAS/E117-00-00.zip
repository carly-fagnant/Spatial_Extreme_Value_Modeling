HEC-RAS study E117_baker.prj: E117-00-00

--- E117_baker.g02 (geometry) --- (continued)

Type RM Length L Ch R = 3 ,9569.5  ,,,
BEGIN DESCRIPTION:
DEIHL
Structure ID: E117-00-00-05
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,25,2.6,0, 79, 79, , , .95, 0, ,,,
    3791  3814.6  3844.6  3854.6    3881  3884.6    4211    4280    4281  4374.6
  4394.6    4421    4431  4444.6    4451  4464.6  4474.6    4491  4494.6  4504.6
    4511    4521    4531    4541  4544.6    4551    4561    4571    4581    4601
    4641    4671  4770.8    4781    4811    4861  4875.5  4898.7    4915  4920.8
  4924.9  4930.8  4940.7  4940.8 4948.07 4948.18 4948.29 4948.41  4948.5    4949
  4969.3  4978.2  4978.3  4978.8  4991.3  4992.2  4993.6  5001.1  5007.9  5009.1
  5010.2  5022.1  5022.2    5039 5039.06 5039.17 5039.28 5039.39  5039.5  5047.7
  5050.1  5050.8  5060.8  5070.8    5085    5095    5115  5131.6  5139.7
    81.5    81.6   81.75   81.79   81.91   81.91   81.71   82.79   82.81   81.67
   81.43   81.11   80.71   80.85   80.91   80.33    79.9   79.24   79.26   79.41
   79.51   80.61   80.81   80.61    80.4   80.41   80.42   80.81   81.21   80.47
   80.53   81.71   81.44   81.41   81.61    80.7   80.81    80.7    80.7    80.7
   80.41      80   78.72   78.68   79.18   81.88   81.88   81.88   81.88   81.88
   81.88   81.88   81.88   81.88   81.88   81.88   81.88   81.88   81.87   81.87
   81.87   81.86   81.86   81.85   81.85   81.85   79.15   79.14   79.13    79.2
   79.16   79.15    79.5    79.8    79.5    79.2    80.1   80.08   80.07
                                                                                
                                                                                
                                                                                
                                                                                
                                                           75.94   76.18   76.18
   76.18   76.18   76.18   76.18   76.18   76.18   76.18   76.18   76.17   76.17
   76.17   76.16   76.16   76.15   76.15   76.15   76.15   76.14   75.44
                                                                        
    3791  3814.6  3844.6  3854.6    3881  3884.6    4211    4280    4281  4374.6
  4394.6    4421    4431  4444.6    4451  4464.6  4474.6    4491  4494.6  4504.6
    4511    4521    4531    4541  4544.6    4551    4561    4571    4581    4601
    4641    4671  4770.8    4781    4811    4861  4875.5  4898.7    4915  4920.8
  4924.9  4930.8  4940.7  4940.8 4948.07 4948.18 4948.29 4948.41  4948.5    4949
  4969.3  4978.2  4978.3  4978.8  4991.3  4992.2  4993.6  5001.1  5007.9  5009.1
  5010.2  5022.1  5022.2    5039 5039.06 5039.17 5039.28 5039.39  5039.5  5047.7
  5050.1  5050.8  5060.8  5070.8    5085    5095    5115  5131.6  5139.7
    81.5    81.6   81.75   81.79   81.91   81.91   81.71   82.79   82.81   81.67
   81.43   81.11   80.71   80.85   80.91   80.33    79.9   79.24   79.26   79.41
   79.51   80.61   80.81   80.61    80.4   80.41   80.42   80.81   81.21   80.47
   80.53   81.71   81.44   81.41   81.61    80.7   80.81    80.7    80.7    80.7
   80.41      80   78.72   78.68   79.18   81.88   81.88   81.88   81.88   81.88
   81.88   81.88   81.88   81.88   81.88   81.88   81.88   81.88   81.87   81.87
   81.87   81.86   81.86   81.85   81.85   81.85   79.15   79.14   79.13    79.2
   79.16   79.15    79.5    79.8    79.5    79.2    80.1   80.08   80.07
                                                                                
                                                                                
                                                                                
                                                                                
                                                           75.94   76.18   76.18
   76.18   76.18   76.18   76.18   76.18   76.18   76.18   76.18   76.17   76.17
   76.17   76.16   76.16   76.15   76.15   76.15   76.15   76.14   75.44
                                                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4978.8, 2 ,4978.8, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   64.11   77.18
     1.2     1.2
   64.05   77.12
Pier Skew, UpSta & Num, DnSta & Num=  ,5009.1, 2 ,5009.1, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   61.16   77.17
     1.2     1.2
    61.1   77.11
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,-1,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=82.99

Type RM Length L Ch R = 1 ,9543    ,125.1,125,124.8
BEGIN DESCRIPTION:
Deihl - 2
END DESCRIPTION:
XS GIS Cut Line= 4
      3081719.13     13874916.98      3081728.01     13873832.65
      3081737.48     13873637.02      3081155.51     13872805.24
#Sta/Elev= 30
    3791   81.69    4211   81.89    4281   82.99    4451   81.09    4491   79.39
    4531   80.99    4551   79.89    4581   81.39    4641   80.59    4671   81.89
    4811   81.79    4915   79.69  4940.7    78.9  4969.3   67.54  4991.3   61.16
  5001.1   60.26  5007.9   61.25  5010.2   64.28  5022.2   67.48  5047.7   79.38
  5060.8   79.16  5131.6   77.98  5139.7   80.19    5235   79.57  5359.7   81.49
  5689.7   79.99  5739.7   81.79  5849.7   82.39  5939.7   81.29  6083.2   81.99
#Mann= 6 ,-1 , 0
    3791     .99       0    4671     .08       0    4915     .04       0
  5060.8     .05       0    5235     .08       0  5359.7     .99       0
#XS Ineff= 2 , 0
       0 4948.55   76.18 5039.44       0   76.18
Permanent Ineff=
       F       F
Bank Sta=4940.7,5047.7
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,9418    ,240.2,223,195.2
BEGIN DESCRIPTION:
Deihl - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
       3081843.9       13874915.      3081852.75     13873834.72
      3081865.32     13873574.81      3081244.15       13872687.
#Sta/Elev= 30
  3795.9   82.26  3825.9   81.47  3865.9   76.13  3895.9   79.96  3915.9   81.14
  4225.9   81.28  4305.9   78.65  4585.9   79.84  4625.9   78.86  4735.9   79.99
  4896.3   78.71    4915   79.78  4940.8   78.99  4969.3   67.88  4991.3    61.5
  5001.1    60.6  5007.9   61.59  5010.2   64.62  5056.3   78.25  5096.3   79.36
  5226.5    78.9  5266.5   80.43  5526.5   80.24  5556.5   81.04  5816.5   81.23
  5886.5   80.35  5926.5   78.76  6046.5    79.3  6116.5   81.56    6220   81.72
#Mann= 7 ,-1 , 0
  3795.9     .99       0  4585.9     .08       0    4915     .04       0
  4940.8     .04       0  5056.3     .05       0  5266.5     .08       0
  5526.5     .99       0
#Block Obstruct= 1 ,-1
  3794.8    4100    79.4
Bank Sta=4940.8,5056.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,9195    ,265.7,198,97.2
BEGIN DESCRIPTION:
Tidwell - 4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
      3082353.47      13874860.5      3082139.44     13873842.99
      3082011.78     13873531.33      3081576.21     13872742.81
#Sta/Elev= 30
  3794.8   80.63  3944.8   79.89  3994.8   75.21  4054.8   80.41  4204.8   80.08
  4294.8   78.74  4414.8   79.78  4484.8   78.09  4544.8   79.46  4744.8   78.14
  4794.8   79.62  4884.6    80.3  4934.6   79.56    4949   76.61  4969.3   68.48
  4991.3    62.1  5001.1    61.2  5007.9   62.19  5010.2   65.22  5034.6   73.11
  5044.6   75.65  5064.6   78.53  5221.4   78.11  5251.4   80.44  5481.4   80.06
  5681.4   81.16  5851.4    80.7  5881.4   79.73  5931.4   80.96  6072.3   80.73
#Mann= 6 ,-1 , 0
  3794.8     .99       0  4294.8     .08       0  4934.6     .04       0
  5064.6     .04       0  5221.4     .08       0  5251.4     .99       0
#XS Ineff= 1 ,-1
  3794.8    4650   80.22
Permanent Ineff=
       F
#Block Obstruct= 1 ,-1
  3794.8    4100    79.4
Bank Sta=4934.6,5064.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,8997    ,136,141,138.3
BEGIN DESCRIPTION:
Tidwell - 3
Detention pond on left overbank
END DESCRIPTION:
XS GIS Cut Line= 4
      3082625.77      13874877.1      3082366.74      13873608.6
      3082100.29     13873596.11      3081674.56      13872838.3
#Sta/Elev= 30
2583.653    81.4 2705.94      802741.907    74.3 2770.68    77.12813.841    79.4
2849.808    78.92913.326   79.752950.516    78.53295.799    78.83353.346    79.7
3449.594   77.533484.842    77.73547.712   77.993553.825    75.63578.284   70.72
3580.154   68.253587.562   62.553589.218   61.743601.231   61.743629.933   67.43
3640.219   70.483676.402   77.023784.375   78.193814.803    80.83879.543    79.7
 3915.51    80.84016.218    79.8 4085.85   80.964282.374    80.34318.341    81.3
#Mann= 9 ,-1 , 0
2583.653     .99       02913.326     .08       03484.842     .04       0
3587.562     .04       03629.933     .04       03676.402     .04       0
3784.375     .08       03814.803     .99       0 4085.85     .99       0
#XS Ineff= 3 ,-1
2583.653 3351.06   80.22 3351.063552.479   77.833656.1694367.328   77.83
Permanent Ineff=
       F       F       F
#Block Obstruct= 1 ,-1
2709.7532813.338    79.4
Bank Sta=3547.712,3676.402
XS Rating Curve= 0
Skew Angle= 44
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,8939    ,,,
BEGIN DESCRIPTION:
TIDWELL; Circular columns; skewed
Structure ID: E117-00-00-04
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,96,2.6,44, 51, 51, , , .95, 0, ,,,
 3353.35 3434.49 3449.59 3463.26 3484.84 3499.88 3520.23 3528.65 3541.17 3541.25
 3541.31 3547.71 3548.79 3551.95 3552.03 3552.11 3552.82 3553.83 3574.18 3578.28
 3580.15 3582.82 3587.56 3587.64 3589.22 3601.23 3605.69 3605.76 3616.27 3626.26
 3629.93 3640.22 3656.04 3656.12 3656.19 3664.32 3666.68 3666.76 3666.83 3666.91
  3676.4 3679.71 3685.75 3700.14 3736.11 3746.03 3750.49 3784.38 3793.22 3800.42
  3814.8
   79.71    79.1   78.21    77.6      78   77.78   77.87   77.91   77.97   77.97
   77.97      78   77.77   77.78   81.58   81.58   81.58   81.58   81.62   81.62
   81.62   81.61   81.61   81.61   81.61    81.6    81.6    81.6   81.59   81.58
   81.58   81.57   81.56   81.56   81.56   81.56   81.56   81.56   81.56   77.76
   78.01    78.1    78.1    78.2    80.6   80.88      81   80.75   80.69   80.63
    80.8
                                                            77.9   77.96   77.96
   77.96   77.99   77.57   76.33    76.3   76.27   75.98   75.98   76.02   76.02
   76.02   76.01   76.01   76.01   76.01      76      76      76   75.99   75.98
   75.98   75.97   75.96   73.01   73.02   74.31
                                                                                
        
 3353.35 3434.49 3449.59 3463.26 3484.84 3499.88 3520.23 3528.65 3541.17 3541.25
 3541.31 3547.71 3548.79 3551.95 3552.03 3552.11 3552.82 3553.83 3574.18 3578.28
 3580.15 3582.82 3587.56 3587.64 3589.22 3601.23 3605.69 3605.76 3616.27 3626.26
 3629.93 3640.22 3656.04 3656.12 3656.19 3664.32 3666.68 3666.76 3666.83 3666.91
  3676.4 3679.71 3685.75 3700.14 3736.11 3746.03 3750.49 3784.38 3793.22 3800.42
  3814.8
   79.71    79.1   78.21    77.6      78   77.78   77.87   77.91   77.97   77.97
   77.97      78   77.77   77.78   81.58   81.58   81.58   81.58   81.62   81.62
   81.62   81.61   81.61   81.61   81.61    81.6    81.6    81.6   81.59   81.58
   81.58   81.57   81.56   81.56   81.56   81.56   81.56   81.56   81.56   77.76
   78.01    78.1    78.1    78.2    80.6   80.88      81   80.75   80.69   80.63
    80.8
                                                            77.9   77.96   77.96
   77.96   77.99   77.57   76.33    76.3   76.27   75.98   75.98   76.02   76.02
   76.02   76.01   76.01   76.01   76.01      76      76      76   75.99   75.98
   75.98   75.97   75.96   73.01   73.02   74.31
                                                                                
        
Pier Skew, UpSta & Num, DnSta & Num=  ,3582.816, 2 ,3582.816, 2 , 0 , 0 , 0 ,,
       2       2
   59.52   77.01
       2       2
    61.1   78.59
Pier Skew, UpSta & Num, DnSta & Num=  ,3626.264, 2 ,3626.264, 2 , 0 , 0 , 0 ,,
       2       2
    65.6   76.98
       2       2
   67.18   78.56
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,-1,1.25,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=81.4

Type RM Length L Ch R = 1 ,8856    ,123.4,198,307.4
BEGIN DESCRIPTION:
Tidwell - 2
END DESCRIPTION:
XS GIS Cut Line= 4
      3082715.51      13874774.6       3082455.7     13873502.31
      3082188.13     13873489.77      3081739.77      13872691.7
#Sta/Elev= 30
2581.495    81.5 2705.94      802741.907    74.3 2770.68    77.12813.841    79.4
2849.808    78.92914.549    79.82950.516    78.53295.799    78.8 3352.64   79.65
3449.594   77.533547.712   77.993551.949   77.873578.284   72.263580.154   69.79
3587.562   64.093589.218   63.283601.231   63.283629.933   68.973640.219   72.02
3676.402   77.023784.375   78.193814.803    80.83879.543    79.7 3915.51    80.8
4016.218    79.8 4085.85   80.964282.374    80.34318.341    81.34366.824    81.1
#Mann= 7 ,-1 , 0
2581.495     .99       02914.549     .08       03449.594     .04       0
3587.562     .04       03629.933     .04       03676.402     .08       0
 4085.85     .99       0
#XS Ineff= 3 ,-1
2581.495 3354.22    79.7  3362.1 3560.68   77.183656.1694366.824      77
Permanent Ineff=
       F       F       F
#Block Obstruct= 1 ,-1
2709.7532813.338    79.4
Bank Sta=3547.712,3676.402
XS Rating Curve= 0
Skew Angle= 44
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,8658    ,341,351,358.5
BEGIN DESCRIPTION:
Tidwell - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
      3082777.77      13874766.6      3082541.21      13873542.6
      3082481.14     13873260.98      3082160.56     13872589.33
#Sta/Elev= 30
  3605.5   80.14  3815.5   79.31  3875.5   79.87  4005.5   77.91  4045.5    79.1
  4185.5   78.76  4235.5   77.32  4295.5   77.52  4315.5   78.32  4455.5   78.84
  4495.5   77.72  4515.5   78.26    4800   77.61  4932.2   77.61  4960.7   75.16
  4979.2   69.14  4993.2    63.9  4995.5   62.47  4999.7    61.8  5004.6   62.37
    5014   68.34  5027.3   69.51  5062.2   78.35  5160.2   78.78  5180.2   79.64
  5360.2      80  5380.2   79.59  5460.2   80.34  5800.2   79.79  5884.4   80.55
#Mann= 6 ,-1 , 0
  3605.5     .99       0  4295.5     .08       0    4800     .04       0
  4932.2     .04       0  5062.2     .08       0  5380.2     .99       0
Bank Sta=4932.2,5062.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,8307    ,722.6,699,660.7
BEGIN DESCRIPTION:
Cross Section XS08
Located At: DS TIDWELL
END DESCRIPTION:
XS GIS Cut Line= 5
      3082803.6913874909.4904849      3082869.09     13873573.37
      3082852.33     13873229.82      3082779.95     13872850.84
      3082252.48     13871988.04
#Sta/Elev= 30
  3456.3    82.2  3586.3    82.6  3646.3    79.7  3866.3    79.8  3946.3    77.7
    4490   78.05  4736.3    77.9    4824    76.5  4926.9   77.81  4949.1   77.61
  4995.5   59.86  4999.7   59.19  5004.6   59.76    5014   65.73  5027.3    66.9
  5051.1    76.8    5074      78    5104    79.3    5188    79.1    5248      77
    5278    79.1    5408    80.1  5603.8    76.8  5693.8    80.6  5813.8      81
  5863.8      80  6303.8    79.8  6453.8    81.4  6473.8    82.5    6535    82.2
#Mann= 7 ,-1 , 0
  3456.3     .99       0    4490     .08       0  4926.9     .04       0
  4949.1     .04       0  5051.1     .04       0    5074     .08       0
  5813.8     .99       0
#XS Ineff= 2 , 0
         4924.12   77.84 5102.98           79.29
Permanent Ineff=
       F       F
Bank Sta=4949.1,5051.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,7608    ,1195.3,1258,1275.1
BEGIN DESCRIPTION:
Cross Section XS07
Located At: 2ND DS TIDWELL
END DESCRIPTION:
XS GIS Cut Line= 6
      3084405.88     13874594.43      3083961.18     13873869.33
      3083604.62     13873191.01      3083357.88       13872917.
      3083136.84      13872699.7      3082287.32      13871953.2
#Sta/Elev= 30
  3111.6      80  3611.6    77.9  4132.2    78.9    4200   77.63  4522.2    76.3
  4848.5      77  4909.3    76.7  4946.8   77.38    4965    68.9  4988.9   63.43
  4992.6   59.07  5000.4   57.72  5007.5    59.1  5016.9   64.65  5035.9   68.61
  5047.9   74.67  5071.7   74.96  5127.3    77.2  5187.3    77.3  5237.3    74.6
  5317.3    79.2    5400   79.38  5537.2    76.5  5607.2    79.5  5777.2    80.9
  5837.2    80.2  5897.2    77.3  5977.2    81.1  6247.2    79.4  6538.1    81.7
#Mann= 8 ,-1 , 0
  3111.6     .99       0    4200     .08       0  4848.5     .06       0
  4909.3     .04       0  4946.8     .04       0  5047.9     .04       0
  5071.7     .08       0    5400     .99       0
#XS Ineff= 2 ,-1
 5316.78  6538.1   79.14 5124.51 5294.72   77.16
Permanent Ineff=
       F       F
Bank Sta=4946.8,5047.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,6350    ,712.5,702,682.9
BEGIN DESCRIPTION:
Cross Section XS06
Located At: 2ND US ANTOINE
END DESCRIPTION:
XS GIS Cut Line= 6
      3085005.21     13874524.74      3084792.56     13873546.52
      3084512.36     13872542.32      3084525.38     13872266.21
      3084205.53     13871840.12      3083967.48     13871486.46
#Sta/Elev= 30
  2839.3    80.8  3079.3    78.7  3499.3    77.2  3679.3    78.2  3739.3    76.1
  3870.4    77.6  3910.4    75.8  3930.4    76.7  3970.4    75.8  4000.4      77
  4210.4    76.8  4460.4    74.1  4830.4    75.3  4880.4    74.6  4911.4   75.77
  4923.8   76.81    4948   65.75  4967.7   64.84  4977.2   56.64    5022   56.46
  5039.9   73.66  5059.1   74.89  5102.9      76  5239.3    73.7  5269.3    75.9
  5439.3    77.6  5509.3    76.1  5569.3    77.8    5690   78.29  6118.4    79.6
#Mann= 8 ,-1 , 0
  2839.3     .99       0  3679.3     .08       0  4830.4     .06       0
  4911.4     .04       0  4923.8     .04       0  5039.9     .04       0
  5059.1     .08       0    5690     .99       0
#XS Ineff= 2 , 0
         4830.42   75.31 5102.75           76.02
Permanent Ineff=
       F       F
Bank Sta=4923.8,5039.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,5648    ,674.9,700,724.2
BEGIN DESCRIPTION:
Cross Section XS05
Located At: US ANTOINE
END DESCRIPTION:
XS GIS Cut Line= 6
      3085574.43     13873976.52      3085259.25     13872695.49
      3085240.31     13872479.22      3085149.67       13872082.
      3085078.57     13871513.12      3084629.69     13871157.58
#Sta/Elev= 30
  3340.5    79.8  3380.5    77.7  3590.5    76.5  4130.5    74.9  4230.5    76.9
  4330.5    74.3  4420.5    76.9  4640.5    75.5  4699.7    72.8  4939.1   75.22
  4941.1   75.22  4968.2   74.05  4990.2   55.85  5007.6   55.83  5016.3   60.37
  5034.9   64.34    5070   76.31  5095.7   76.22    5201    76.3    5251    74.3
  5284.6    76.4    5540   76.25  5584.6    78.3  5804.6    77.1  5857.9    78.8
  6067.9      79  6117.9    76.7  6217.9    78.5  6267.9    76.3  6430.5    79.1
#Mann= 7 ,-1 , 0
  3340.5     .99       0  4230.5     .08       0  4939.1     .04       0
  4968.2     .04       0    5070     .04       0  5095.7     .08       0
    5540     .99       0
#XS Ineff= 2 , 0
         4934.96   75.24 5160.99            76.5
Permanent Ineff=
       F       F
Bank Sta=4941.1,5070
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,4948    ,400.1,400,401.1
BEGIN DESCRIPTION:
Antoine - 4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 5
      3085871.26      13873951.5      3085861.93     13872563.05
      3085891.06     13872040.55      3085887.08     13871856.74
       3085370.3     13870996.93
#Sta/Elev= 30
  3262.8   79.15  3302.8    77.9  3742.8   75.43  3792.8   76.56  4062.8   76.65
  4112.8   74.55  4332.8   74.09  4821.3   74.27  4891.3   72.94  4931.3   74.09
  4978.7   65.67  4985.5    59.4  4990.2   56.55  5007.6   56.53  5013.6   58.69
  5016.3   61.07  5071.3   73.71  5204.6   74.37  5264.6   73.15  5388.5   72.98
  5448.5   75.63  5548.5   73.88  5618.5   77.08  5798.5    77.5  5868.5   75.34
  5918.5   77.58  6088.5   78.82  6158.5   76.12  6248.5   78.74  6361.6   78.85
#Mann= 5 ,-1 , 0
  3262.8     .99       0  4332.8     .08       0  4931.3     .04       0
  5071.3     .08       0  5798.5     .99       0
#XS Ineff= 1 ,-1
  3262.8 4293.22   75.73
Permanent Ineff=
       F
Bank Sta=4931.3,5071.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,4548    ,113.1,113,113.3
BEGIN DESCRIPTION:
Antoine - 3
END DESCRIPTION:
XS GIS Cut Line= 5
      3086271.25      13873948.8        3086262.     13872572.84
       3086291.3     13872047.37      3086284.69      13871741.8
      3085713.14     13870790.87
#Sta/Elev= 30
  3298.1   79.79  3377.9   79.79  3807.9   75.39  4127.9   75.19  4157.9   73.89
  4397.9   74.89  4673.9   73.59  4806.3   74.35  4817.3   73.22  4925.8   74.03
  4935.6    74.1  4981.9   62.18  4982.2   61.41    4990   59.19  4993.9   56.93
  5009.8   58.28  5009.9   59.29  5017.1   60.71  5040.9   70.39  5062.5   74.74
  5095.8   74.61  5505.8   74.99    5750   76.49  6095.8   77.59  6205.8   74.79
  6225.8   74.89  6265.8   77.09  6385.8   78.19  6565.8   75.89  6615.5   78.39
#Mann= 6 ,-1 , 0
  3298.1     .99       0  4397.9     .08       0  4925.8     .04       0
  5040.9     .04       0  5095.8     .08       0    5750     .99       0
#XS Ineff= 3 ,-1
  3298.1 4393.22   75.73 4393.22 4947.14    74.1  5040.8  6615.5   74.71
Permanent Ineff=
       F       F       F
Bank Sta=4935.6,5062.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,4493    ,,,
BEGIN DESCRIPTION:
ANTOINE; Circular columns; Concrete abutments
Structure ID: E117-00-00-03
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,90,2.6,0, 65, 65, , , .95, 0, ,,,
  3297.9  3377.9  3395.4  3685.4  3765.4  3807.9  3835.4  3865.4  3875.4  3905.4
  3915.4  3945.4  3955.4  3965.4  3985.4  4065.4  4115.4  4127.9  4135.4  4157.9
  4185.4  4205.4  4345.4  4377.9    4397  4397.9  4497.9  4673.9  4715.8  4806.3
  4817.3  4925.8  4935.6 4940.89    4941 4941.11 4947.31  4947.4  4965.2  4981.9
  4982.2  4989.9    4990  4990.1  4993.9  5009.8  5009.9    5010  5017.1  5017.2
    5025 5040.79  5040.9    5041 5045.69  5045.8 5045.91  5062.5  5066.1  5075.8
  5078.6  5085.8  5095.8  5152.3  5160.3
    79.8    79.8    80.5      78   75.84   76.06    76.3   75.37    75.4    78.2
    78.1   75.32   75.32   75.31    76.4    76.8   75.22   75.21   74.89   74.11
      74      74    75.4   75.15   75.01      75   74.25   73.61   73.85   74.37
   73.52    74.5    75.3   75.73   78.33   78.33   78.33   78.33   78.35   78.36
   78.36   78.36   78.36   78.36   78.37   78.38   78.38   78.38   78.38   78.38
   78.39    78.4    78.4    78.4    78.4    78.4    75.8   75.28   75.17   74.71
    74.7   74.67    74.8   74.68      75
                                                                                
                                                                                
                                                                                
                                                   71.09   72.23   72.25   72.26
   72.26   72.26   72.26   72.26   72.27   72.28   72.28   72.28   72.28   72.28
   72.29    72.3    70.4
                                        
  3297.9  3377.9  3395.4  3685.4  3765.4  3807.9  3835.4  3865.4  3875.4  3905.4
  3915.4  3945.4  3955.4  3965.4  3985.4  4065.4  4115.4  4127.9  4135.4  4157.9
  4185.4  4205.4  4345.4  4377.9    4397  4397.9  4497.9  4673.9  4715.8  4806.3
  4817.3  4925.8  4935.6 4940.89    4941 4941.11 4947.31  4947.4  4965.2  4981.9
  4982.2  4989.9    4990  4990.1  4993.9  5009.8  5009.9    5010  5017.1  5017.2
    5025 5040.79  5040.9    5041 5045.69  5045.8 5045.91  5062.5  5066.1  5075.8
  5078.6  5085.8  5095.8  5152.3  5160.3
    79.8    79.8    80.5      78   75.84   76.06    76.3   75.37    75.4    78.2
    78.1   75.32   75.32   75.31    76.4    76.8   75.22   75.21   74.89   74.11
      74      74    75.4   75.15   75.01      75   74.25   73.61   73.85   74.37
   73.52    74.5    75.3   75.73   78.33   78.33   78.33   78.33   78.35   78.36
   78.36   78.36   78.36   78.36   78.37   78.38   78.38   78.38   78.38   78.38
   78.39    78.4    78.4    78.4    78.4    78.4    75.8   75.28   75.17   74.71
    74.7   74.67    74.8   74.68      75
                                                                                
                                                                                
                                                                                
                                                   71.09   72.23   72.25   72.26
   72.26   72.26   72.26   72.26   72.27   72.28   72.28   72.28   72.28   72.28
   72.29    72.3    70.4
                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4982.2, 2 ,4982.2, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   60.21   73.26
     1.5     1.5
   59.89   72.94
Pier Skew, UpSta & Num, DnSta & Num=  ,5017.2, 2 ,5017.2, 2 , 0 , 0 , 0 ,,
     1.5     1.5
   59.59   73.28
     1.5     1.5
   59.27   72.96
Abutment Skew #Up #Dn= , 2 , 2
  4947.2    4990
   72.23    59.2
  4947.2    4990
   71.91   58.88
Abutment Skew #Up #Dn= , 2 , 2
    5010 5040.99
   59.32    72.3
    5010 5040.99
      59   71.98
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,-1,1.25,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 99
  3297.9   79.79  3377.9   79.79  3395.4   79.61  3685.4   76.64  3765.4   75.82
  3807.9   75.39  3835.4   75.37  3865.4   75.35  3875.4   75.35  3905.4   75.33
  3915.4   75.32  3945.4    75.3  3955.4    75.3  3965.4   75.29  3985.4   75.28
  4065.4   75.23  4115.4    75.2  4127.9   75.19  4135.4   74.87  4157.9   73.89
  4185.4   73.94  4205.4   73.98  4345.4   74.23  4377.9   74.29    4397   74.86
  4397.9   74.89  4497.9   74.09  4673.9   73.59  4715.8   73.83  4806.3   74.35
  4817.3   73.22  4925.8   74.03  4935.6    74.1 4940.89   72.73    4941   72.71
 4941.11   72.68 4947.31   71.08  4947.4   71.05  4965.2   66.46  4982.2   61.41
  4989.9   59.22    4990   59.19  4990.1   58.38  4993.9   56.93  5009.8   58.28
  5009.9   59.29    5010   59.31  5017.1   60.71  5017.2   60.81    5025   64.32
 5040.79   70.35  5040.9   70.39    5041   70.41 5045.69   71.35  5045.8   71.38
 5045.91    71.4  5062.5   74.74  5066.1   74.73  5075.8   74.69  5078.6   74.68
  5085.8   74.65  5095.8   74.61  5152.3   74.38  5160.3   74.98  5200.2   74.89
  5280.2   75.09  5435.8   75.02  5485.8      75  5505.8   74.99  5587.8   75.49
  5647.8   75.86  5697.8   76.17  5717.8   76.29    5750   76.49  5765.8   76.59
  5787.8   76.62  5925.8   76.79  5967.8   76.99  5997.8   77.13  6017.8   77.22
  6057.8   77.41  6095.8   77.59  6205.8   74.79  6225.8   74.89  6247.8    76.1
  6265.8   77.09  6267.8   77.11  6317.8   77.57  6337.8   77.75  6367.8   78.02
  6385.8   78.19  6437.8   77.57  6485.8   76.99  6505.8   76.19  6545.8   76.19
  6565.8   75.89  6615.3   78.39  6657.8   78.25  6705.3   78.09
BR U #Mann= 9
  3297.9     .99  4065.4     .08  4925.8     .04  4935.6    .015  4982.2     .04
  5017.2    .015  5062.5     .04  5095.8     .08    5750     .99
BR D #Sta/Elev= 99
  3297.9   79.79  3377.9   79.79  3395.4   79.61  3685.4   76.64  3765.4   75.82
  3807.9   75.39  3835.4   75.37  3865.4   75.35  3875.4   75.35  3905.4   75.33
  3915.4   75.32  3945.4    75.3  3955.4    75.3  3965.4   75.29  3985.4   75.28
  4065.4   75.23  4115.4    75.2  4127.9   75.19  4135.4   74.87  4157.9   73.89
  4185.4   73.94  4205.4   73.98  4345.4   74.23  4377.9   74.29    4397   74.86
  4397.9   74.89  4497.9   74.09  4673.9   73.59  4715.8   73.83  4806.3   74.35
  4817.3   73.22  4925.8   74.03  4935.6   73.77 4940.89    72.4    4941   72.38
 4941.11   72.35 4947.31   70.75  4947.4   70.72  4965.2   66.13  4982.2   61.08
  4989.9   58.89    4990   58.86  4990.1   58.05  4993.9    56.6  5009.8   57.95
  5009.9   58.96    5010   58.98  5017.1   60.38  5017.2   60.48    5025   63.99
 5040.79   70.02  5040.9   70.06    5041   70.08 5045.69   71.02  5045.8   71.05
 5045.91   71.07  5062.5   74.41  5066.1   74.73  5075.8   74.69  5078.6   74.68
  5085.8   74.65  5095.8   74.61  5152.3   74.38  5160.3   74.98  5200.2   74.89
  5280.2   75.09  5435.8   75.02  5485.8      75  5505.8   74.99  5587.8   75.49
  5647.8   75.86  5697.8   76.17  5717.8   76.29    5750   76.49  5765.8   76.59
  5787.8   76.62  5925.8   76.79  5967.8   76.99  5997.8   77.13  6017.8   77.22
  6057.8   77.41  6095.8   77.59  6205.8   74.79  6225.8   74.89  6247.8    76.1
  6265.8   77.09  6267.8   77.11  6317.8   77.57  6337.8   77.75  6367.8   78.02
  6385.8   78.19  6437.8   77.57  6485.8   76.99  6505.8   76.19  6545.8   76.19
  6565.8   75.89  6615.3   78.39  6657.8   78.25  6705.3   78.09
BR D #Mann= 9
  3297.9     .99  4065.4     .08  4925.8     .04  4935.6    .015  4982.2     .04
  5017.1    .015  5062.5     .04  5095.8     .08    5750     .99
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=79.79

Type RM Length L Ch R = 1 ,4435    ,118.7,106,91.9
BEGIN DESCRIPTION:
Antoine - 2
END DESCRIPTION:
XS GIS Cut Line= 5
      3086384.38      13873952.1      3086375.13     13872576.29
      3086404.43     13872050.78      3086397.78     13871743.69
      3085825.56     13870791.63
#Sta/Elev= 30
  3297.9   79.46  3377.9   79.79  3807.9   75.39  4127.9   75.19  4157.9   73.89
  4397.9   74.89  4497.9   74.09  4806.3   74.35  4817.3   73.22  4925.8   74.03
  4935.6   73.77  4981.9   61.85  4982.2   61.08    4990   58.86  4990.1   58.05
  4993.9    56.6  5009.8   57.95  5009.9   58.96  5017.1   60.38  5040.9   70.06
  5062.5   74.41  5095.8   74.61  5505.8   74.99    5750   76.49  6095.8   77.59
  6205.8   74.79  6265.8   77.09  6385.8   78.19  6565.8   75.89  6615.3   78.39
#Mann= 7 ,-1 , 0
  3297.9     .99       0  4497.9     .08       0  4925.8     .04       0
  4982.2     .04       0  5062.5     .04       0  5095.8     .08       0
    5750     .99       0
#XS Ineff= 3 ,-1
  3297.9 4393.22   75.63 4393.22 4947.14    73.2  5040.8  6615.3    73.2
Permanent Ineff=
       F       F       F
Bank Sta=4935.6,5062.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,4329    ,435.5,412,387.2
BEGIN DESCRIPTION:
Antoine - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 6
      3086484.37      13873951.4      3086477.37     13872909.07
      3086513.51     13872331.97      3086473.38     13872120.14
      3086475.87     13871683.77      3085911.27     13870740.11
#Sta/Elev= 30
  3268.8   79.47  3338.8   77.13  3688.8   75.91  3748.8   78.03  3828.8   75.34
  3888.8   77.99  4048.8   76.62  4128.8   73.68  4188.8   73.47  4311.2   75.46
    4500   74.83  4751.2   72.59  4919.4   73.59  4929.4   73.32  4961.5   68.78
  4988.8   57.64  5000.9   56.42  5014.8   59.01  5051.2   73.07    5075   74.09
    5215   73.24  5541.4    75.8  5781.4   74.56  5871.4    76.3  5911.4   75.53
  5991.4   77.44  6431.4   77.18  6471.4   75.23  6541.4   76.86  6641.1   77.24
#Mann= 7 ,-1 , 0
  3268.8     .99       0    4500     .08       0  4919.4     .04       0
  4929.4     .04       0  5051.2     .04       0    5075     .08       0
  5781.4     .99       0
#XS Ineff= 1 ,-1
  3268.8 4293.22   75.63
Permanent Ineff=
       F
Bank Sta=4929.4,5051.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,3917    ,335.2,338,340.1
BEGIN DESCRIPTION:
Cross Section XS04
Right overbank has a detention pond.
END DESCRIPTION:
XS GIS Cut Line= 6
      3086817.16     13873620.13      3086983.14     13872213.41
      3086920.27     13872126.65      3086739.71     13871837.76
      3086827.71     13871669.07      3087193.31     13871036.29
#Sta/Elev= 30
  3344.7    80.7  3594.7    78.4  3634.7    71.2  3664.7    69.9  3794.7    70.2
  3864.7    76.6  3924.7    76.4  3984.7    78.7  4174.7    76.9  4254.7    73.7
  4444.7      73    4490   74.27  4926.1   73.31  4946.6   73.85  4988.8   56.93
  5000.9   55.71  5014.8    58.3  5051.2   72.36  5069.9   73.17  5098.3    72.4
  5168.3    74.9    5525    75.2  5589.3    74.1  5709.3    75.7  5759.3    74.8
  5839.3    76.6  5959.3    75.1  6009.3    77.3  6109.3    76.3  6130.1    78.3
#Mann= 9 ,-1 , 0
  3344.7     .05       0  3594.7    .026       0  3984.7     .05       0
    4490     .08       0  4926.1     .04       0  4946.6     .04       0
  5051.2     .04       0  5069.9     .08       0    5525     .99       0
#XS Ineff= 2 , 0
         4909.83      75
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
    3600    3983    78.4
Bank Sta=4946.6,5051.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,3579    ,150,206,253.7
BEGIN DESCRIPTION:
Railroad_1 - 4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
      3086852.41      13873538.7       3087185.1     13871921.45
      3087097.22     13871764.92      3087171.37     13871182.72
#Sta/Elev= 30
  3263.8   80.81  3423.8    79.1  3633.8   71.26  3683.8   76.21  3763.8   76.29
  3823.8   78.77  4073.8   77.08  4163.8   74.42  4213.8   74.97  4363.8   72.23
  4423.8   72.47  4523.8   78.32  4633.8   71.15  4733.8   72.29    4945   73.58
  4964.5   70.51  4975.6   66.04  4985.9   57.79  4990.1   56.04  4998.7   55.87
  5010.6   56.46    5043   70.97    5065   72.96  5094.5   73.39  5134.5   74.96
  5234.5   73.71  5314.5   75.56  5494.5   75.04  5574.5   76.42  5681.4   74.99
#Mann= 8 ,-1 , 0
  3263.8     .99       0  4213.8     .08       0  4423.8     .05       0
  4733.8     .08       0    4945     .04       0    5065     .04       0
  5094.5     .08       0  5494.5     .99       0
#XS Ineff= 2 , 0
       0    4920      75               0
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
    3300    3850    78.4
Bank Sta=4945,5065
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,3373    ,39.4,40,39.9
BEGIN DESCRIPTION:
Railroad_1 - 3
Right overbank has a ditch spilling to E117
END DESCRIPTION:
XS GIS Cut Line= 4
      3086868.68      13873554.1      3087238.67     13872002.45
      3087439.42     13871626.74      3087195.62     13871156.65
#Sta/Elev= 30
  3205.6    80.8  3274.3    80.1  3304.3    77.5  3334.3    76.7  3394.3      78
  3604.3    75.6  3634.3    76.4  4234.3    74.5  4484.3    72.1  4534.3    70.8
  4654.3    77.5  4694.3      78  4744.3    74.6  4752.9   76.32  4929.6   75.02
  4948.7   74.88  4954.3   72.84  4977.3   59.48  4987.5    57.2  5001.3   57.26
  5005.4   55.96  5019.9   58.68  5033.6   63.25  5053.4   73.17  5067.9   76.15
    5465    75.7  5515.5    74.1  5655.5    76.3  5715.5    74.9  5756.4    77.1
#Mann= 6 ,-1 , 0
  3205.6     .99       0  4234.3     .08       0  4484.3     .05       0
  4929.6     .04       0  5067.9     .08       0    5465     .99       0
#XS Ineff= 2 , 0
       0 4949.34   74.64 5060.34       0   74.64
Permanent Ineff=
       F       F
Bank Sta=4948.7,5067.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,3353.5  ,,,
BEGIN DESCRIPTION:
CR&IRR (BNSF); Circular columns
Structure ID: E117-00-00-02
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,19,2.6,0, 41, 41, , , .95, 0, ,,,
  4714.3  4724.3  4741.4  4744.3  4751.4  4752.9  4771.4  4820.5  4919.7  4929.6
  4948.7 4949.27 4949.38 4949.49 4949.61  4949.7  4954.3  4977.3  4979.9  4987.4
  4987.5  5001.3  5005.4  5012.3  5012.4  5019.9  5033.6  5053.4 5060.33 5061.26
 5061.37 5061.48 5061.59  5061.7  5061.9  5067.9  5167.1  5182.6  5212.6  5226.9
  5246.9
   76.91   76.51    75.7   76.08      77   77.09    78.2   78.43    78.6   78.57
   78.51   78.51   82.01   82.01   82.01   82.01   82.01   82.01      82      82
      82      82      82      82      82      82   81.99   81.99   81.99   81.99
   81.99   78.49   78.49   78.49   78.49   78.47    78.2    77.9    77.8    77.7
   75.86
    76.9    76.5   74.88    74.6   76.02   76.32   76.18   75.82   75.09   75.02
   74.88   74.67   74.63   74.59   74.55   74.61   74.61   74.61    74.6    74.6
    74.6    74.6    74.6    74.6    74.6    74.6   74.59   74.59   74.59   74.79
   74.81   74.83   74.85   74.88   74.92   76.15   75.98   75.96   75.91   75.88
   75.85
  4714.3  4724.3  4741.4  4744.3  4751.4  4752.9  4771.4  4820.5  4919.7  4929.6
  4948.7 4949.27 4949.38 4949.49 4949.61  4949.7  4954.3  4977.3  4979.9  4987.4
  4987.5  5001.3  5005.4  5012.3  5012.4  5019.9  5033.6  5053.4 5060.33 5061.26
 5061.37 5061.48 5061.59  5061.7  5061.9  5067.9  5167.1  5182.6  5212.6  5226.9
  5246.9
   76.91   76.51    75.7   76.08      77   77.09    78.2   78.43    78.6   78.57
   78.51   78.51   82.01   82.01   82.01   82.01   82.01   82.01      82      82
      82      82      82      82      82      82   81.99   81.99   81.99   81.99
   81.99   78.49   78.49   78.49   78.49   78.47    78.2    77.9    77.8    77.7
   75.86
                                                                                
                                           74.61   74.61   74.61    74.6    74.6
    74.6    74.6    74.6    74.6    74.6    74.6   74.59   74.59   74.59
                                                                                
        
Pier Skew, UpSta & Num, DnSta & Num=  ,4977.4, 2 ,4977.4, 2 , 0 , 0 , 0 ,,
       2       2
   58.12   75.61
       2       2
   57.83   75.32
Pier Skew, UpSta & Num, DnSta & Num=  ,5005.4, 2 ,5005.4, 2 , 0 , 0 , 0 ,,
       2       2
   55.15    75.6
       2       2
   54.86   75.31
Pier Skew, UpSta & Num, DnSta & Num=  ,5033.6, 2 ,5033.6, 2 , 0 , 0 , 0 ,,
       2       2
   61.92   75.59
       2       2
   61.63    75.3
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,1.25,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 121
  3191.4    80.5  3204.3    80.8  3271.4   80.13  3274.3    80.1  3291.4   78.99
  3294.3    78.8  3301.4   77.88  3304.3    77.5  3321.4   77.04  3334.3    76.7
  3341.4   76.96  3361.4   77.69  3364.3    77.8  3374.3    77.6  3394.3      78
  3401.4   77.95  3411.4   77.87  3441.4   77.64  3471.4   77.41  3524.3      77
  3551.4   76.01  3554.3    75.9  3604.3    75.6  3634.3    76.4  3651.4   76.34
  3661.4   76.31  3711.4   76.14  3724.3    76.1  3731.4   76.09  3741.4   76.07
  3781.4      76  3891.4    75.8  4054.3    75.5  4104.3    74.3  4111.4   74.31
  4211.4   74.46  4234.3    74.5  4424.3    73.2  4484.3    72.1  4491.4   71.82
  4514.3    70.9  4534.3    70.8  4611.4      75  4624.3    75.7  4631.4   76.27
  4634.3    76.5  4641.4   76.64  4644.3    76.7    4650   77.16  4654.3    77.5
  4661.4   77.59  4671.4   77.71  4681.4   77.84  4694.3      78  4704.3    76.9
  4711.4    76.9  4714.3    76.9  4724.3    76.5  4741.4   74.88  4744.3    74.6
  4751.4   76.02  4752.9   76.32  4771.4   76.18  4811.4   75.89  4820.5   75.82
  4919.7   75.09  4929.6   75.02  4948.7   74.88 4949.27   74.67 4949.38   74.63
 4949.49   74.59 4949.61   74.55  4949.7   74.52  4954.3   72.84  4977.3   59.48
  4979.9   58.63  4987.4   57.22  4987.5    57.2  5001.3   57.26  5005.4   55.96
  5012.3   57.24  5012.4   57.26  5019.9   58.68  5033.6   63.25  5053.4   73.17
 5061.26   74.79 5061.37   74.81 5061.48   74.83 5061.59   74.85  5061.7   74.88
  5061.9   74.92  5067.9   76.15  5167.1   75.98  5182.6   75.96  5202.6   75.93
  5212.6   75.91  5226.9   75.88  5246.9   75.85  5256.9   75.83  5265.9   75.82
  5355.5    75.4    5465    75.7  5465.5    75.7  5476.9   75.34  5515.5    74.1
  5535.5    74.3  5536.9   74.36  5565.5    75.6  5606.9   75.92  5655.5    76.3
  5666.9   75.73  5685.5    74.8  5696.9   74.84  5715.5    74.9  5725.5    75.4
  5726.9   75.51  5736.9   76.31  5745.5      77  5755.1    77.1  5766.9   77.52
  5780.6      78
BR U #Mann= 7
  3191.4     .99  4234.3     .08  4484.3     .05  4929.6     .04 4949.49    .045
  5067.9     .08    5465     .99
BR D #Sta/Elev= 121
  3191.4    80.5  3204.3    80.8  3271.4   80.13  3274.3    80.1  3291.4   78.99
  3294.3    78.8  3301.4   77.88  3304.3    77.5  3321.4   77.04  3334.3    76.7
  3341.4   76.96  3361.4   77.69  3364.3    77.8  3374.3    77.6  3394.3      78
  3401.4   77.95  3411.4   77.87  3441.4   77.64  3471.4   77.41  3524.3      77
  3551.4   76.01  3554.3    75.9  3604.3    75.6  3634.3    76.4  3651.4   76.34
  3661.4   76.31  3711.4   76.14  3724.3    76.1  3731.4   76.09  3741.4   76.07
  3781.4      76  3891.4    75.8  4054.3    75.5  4104.3    74.3  4111.4   74.31
  4211.4   74.46  4234.3    74.5  4424.3    73.2  4484.3    72.1  4491.4   71.82
  4514.3    70.9  4534.3    70.8  4611.4      75  4624.3    75.7  4631.4   76.27
  4634.3    76.5  4641.4   76.64  4644.3    76.7    4650   77.16  4654.3    77.5
  4661.4   77.59  4671.4   77.71  4681.4   77.84  4694.3      78  4704.3    76.9
  4711.4    76.9  4714.3    76.9  4724.3    76.5  4741.4   74.88  4744.3    74.6
  4751.4   76.02  4752.9   76.32  4771.4   76.18  4811.4   75.89  4820.5   75.82
  4919.7   75.09  4929.6   75.02  4948.7   74.88 4949.27   74.29 4949.38   74.25
 4949.49   74.21 4949.61   74.17  4949.7   74.14  4954.3   72.46  4977.3    59.1
  4979.9   58.25  4987.4   56.84  4987.5   56.82  5001.3   56.88  5005.4   55.58
  5012.3   56.86  5012.4   56.88  5019.9    58.3  5033.6   62.87  5053.4   72.79
 5061.26   74.41 5061.37   74.43 5061.48   74.45 5061.59   74.47  5061.7    74.5
  5061.9   74.54  5067.9   76.15  5167.1   75.98  5182.6   75.96  5202.6   75.93
  5212.6   75.91  5226.9   75.88  5246.9   75.85  5256.9   75.83  5265.9   75.82
  5355.5    75.4    5465    75.7  5465.5    75.7  5476.9   75.34  5515.5    74.1
  5535.5    74.3  5536.9   74.36  5565.5    75.6  5606.9   75.92  5655.5    76.3
  5666.9   75.73  5685.5    74.8  5696.9   74.84  5715.5    74.9  5725.5    75.4
  5726.9   75.51  5736.9   76.31  5745.5      77  5755.1    77.1  5766.9   77.52
  5780.6      78
BR D #Mann= 7
  3191.4     .99  4234.3     .08  4484.3     .05  4929.6     .04 4949.49    .045
  5067.9     .08    5465     .99
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=80.8

Type RM Length L Ch R = 1 ,3333    ,100.1,100,100
BEGIN DESCRIPTION:
Railroad_1 - 2
Right overbank has a ditch spilling to E117
END DESCRIPTION:
XS GIS Cut Line= 4
      3086903.49     13873571.96      3087273.33     13872020.88
      3087475.02     13871643.41 3087232.255917613871175.3296987
#Sta/Elev= 30
  3205.3   80.42  3274.3    80.1  3304.3    77.5  3334.3    76.7  3394.3      78
  3604.3    75.6  3634.3    76.4  4234.3    74.5  4424.3    73.2  4534.3    70.8
  4654.3    77.5  4694.3      78  4744.3    74.6  4752.9   76.32  4929.6   75.02
  4948.7   74.88  4977.3    59.1  4987.5   56.82  5001.3   56.88  5005.4   55.58
  5019.9    58.3  5033.6   62.87  5053.4   72.79  5067.9   76.15    5465    75.7
  5515.5    74.1  5655.5    76.3  5685.5    74.8  5715.5    74.9  5755.1    77.1
#Mann= 6 ,-1 , 0
  3205.3     .99       0  4234.3     .08       0  4424.3     .05       0
  4929.6     .04       0  5067.9     .08       0    5465     .99       0
#XS Ineff= 2 , 0
       0 4949.34   74.64 5060.34       0   74.64
Permanent Ineff=
       F       F
Bank Sta=4948.7,5067.9
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,3233    ,409,401,391.5
BEGIN DESCRIPTION:
Railroad_1 - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
       3087000.7      13873595.1      3087367.61     13872056.62
      3087588.02     13871644.11      3087321.02     13871129.28
#Sta/Elev= 30
  3228.4   78.74  3308.4   76.45  3548.4    77.4  3778.4   75.57  3808.4   77.38
  3858.4   78.36  3978.4   77.95  4178.4   74.79  4438.4   72.11  4698.4    72.9
  4940.1   72.39  4964.5   69.33  4975.6   64.86  4985.9   56.61  4990.1   54.86
  4998.7   54.69  5010.6   55.28    5043   69.79  5050.1   70.32  5070.1   74.39
  5327.8   74.98  5387.8   71.81  5407.8   76.26  5417.8   77.44  5427.8   77.19
  5457.8   73.09  5487.8   73.91  5597.8   75.27  5827.8   74.81  5857.7      77
#Mann= 5 ,-1 , 0
  3228.4     .99       0  4178.4     .08       0  4940.1     .04       0
  5070.1     .08       0  5487.8     .99       0
Bank Sta=4940.1,5070.1
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,2832    ,183.2,174,160.1
BEGIN DESCRIPTION:
Bolivia - 4
Cross Section XS03
Located At: US HARDWAY
END DESCRIPTION:
XS GIS Cut Line= 4
      3087788.2513873215.1045658      3087774.38     13872188.52
      3087877.87     13871888.23      3087983.05     13870883.91
#Sta/Elev= 30
  3846.7      79  3866.7    74.6  3916.7    73.3  4106.7    73.5  4136.7    72.2
  4186.7    73.4  4316.7    73.4  4496.7    71.4    4547    72.9  4926.7   70.85
  4952.7   70.58  4975.6   61.27  4985.9   53.02  4990.1   51.27  4998.7    51.1
  5010.6   51.69  5015.1   54.35    5058   72.01  5070.9   72.24    5114      73
    5221    70.8    5261    73.5    5361    74.2    5401    72.2    5431    72.3
    5481    75.8    5851    75.8    5901    74.7    5931    76.2  6200.8    77.3
#Mann= 7 ,-1 , 0
  3846.7     .99       0    4547     .08       0  4926.7     .04       0
  4952.7     .04       0    5058     .04       0  5070.9     .08       0
    5114     .99       0
Bank Sta=4952.7,5058
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,2658    ,55.5,54,55.1
BEGIN DESCRIPTION:
Bolivia - 3
END DESCRIPTION:
XS GIS Cut Line= 4
      3087812.3313873224.7246427      3087968.89     13872221.37
      3088008.76     13871909.89      3087999.37      13870884.4
#Sta/Elev= 30
  3881.9   82.53  3891.9   78.93  3911.9   74.93  3951.9   73.43  4191.9   72.43
  4261.9   73.93  4411.9   73.53  4491.9   71.43    4521   72.77  4761.9   69.83
  4939.6   69.79  4952.1   69.87  4998.3   50.61    5019      56  5059.4   70.67
  5074.1   70.54  5241.9   70.13  5271.9   73.13    5375   74.07  5441.9   72.03
  5481.9   75.13  5561.9   75.83  5651.9   73.83  5701.9   74.03  5751.9   76.73
  5871.9   76.63  5901.9   74.53  5931.9   74.53  5971.9   76.13  6239.7   77.13
#Mann= 7 ,-1 , 0
  3881.9     .99       0    4521     .08       0  4939.6     .04       0
  4952.1     .04       0  5059.4     .04       0  5074.1     .08       0
    5375     .99       0
#XS Ineff= 2 , 0
       0    4958   69.77  5057.5       0   69.97
Permanent Ineff=
       F       F
Bank Sta=4952.1,5059.4
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,2631    ,,,
BEGIN DESCRIPTION:
BOLIVIA
Structure ID: E117-00-00-01
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,34,2.6,0, 121, 121, , , .95, 0, ,,,
  3881.9  3890.9  3891.9  3900.9  3901.9  3910.9  3911.9  3950.9  3951.9  4000.9
  4001.9  4020.9  4031.9  4140.9  4151.9  4190.9  4191.9  4261.9  4411.9  4430.9
  4461.9  4480.9  4490.9  4491.9  4501.9    4521  4521.9  4550.9  4641.9  4740.9
  4761.9  4780.9  4860.9  4883.2  4885.9  4903.1  4933.2  4939.6  4943.2  4952.1
  4953.2 4957.69  4957.8 4957.91    4958 4958.11  4958.2  4985.5  4986.6  4986.7
  4998.3  5003.6  5013.2  5013.3    5019  5025.3 5057.36 5057.47 5057.58 5057.69
  5057.8  5059.4  5063.2  5073.2  5074.1  5103.2  5113.2  5134.1  5153.2  5184.3
  5206.2  5211.9  5241.9  5256.2  5261.9  5271.9  5276.2  5361.9    5375  5376.2
  5381.9  5411.9  5416.2  5441.9  5446.2  5451.9  5476.2  5481.9  5506.2  5546.2
  5561.9  5591.9  5606.2  5611.9  5626.2  5636.2  5651.9  5701.9  5721.9  5726.2
  5751.9  5756.2  5871.9  5876.2  5901.9  5906.2  5931.9  5936.2  5971.9  5986.2
  6101.9  6131.9  6136.2  6161.9  6166.2  6191.9  6196.2  6211.9  6216.2  6237.5
  6239.7
    82.5    79.4   79.14    76.8   76.62   75.07   74.96    73.5   73.51    74.2
   74.17   73.73   73.53    73.8   73.49   72.43   72.41   73.91   73.51    73.6
   72.51   71.81   71.45   71.43   71.68   72.75   72.81    72.9   72.31    71.6
   70.44   69.84      70      70      70    69.8    69.8   69.77   69.79   69.85
   69.41   70.31   73.11   73.11   73.11   73.11   73.11   73.31   73.32   73.32
    73.4   73.44    73.5    73.5   73.53   73.57   73.75   73.75   70.95   70.93
    70.9   70.65   70.62   70.52   70.52   70.25   70.16   69.97    70.3   70.84
   70.26   70.11   70.23    71.4   71.91   73.11   73.17   74.31   74.05   74.02
   73.91   72.01   72.01   72.01   72.14   72.55    74.9   75.11    75.6   75.67
   75.81   75.63    75.7   75.61   74.97   74.52   73.93   74.05   74.81   75.08
   76.71   76.71   76.61    76.5   74.87    74.6   74.51   74.68   76.11   76.13
   76.52   76.71    76.7   76.41   76.47   76.81   76.96   77.51    77.5   77.21
    77.1
                                                                                
                                                                                
                                                                                
                                                                                
                   67.57   67.53   67.49   67.45   68.21   68.41   68.42   68.42
    68.5   68.54    68.6    68.6   68.63   68.67   68.85   68.85   69.87   69.92
   69.96   70.64   70.61   70.51   70.51   70.24   70.15   69.96   70.29   70.83
   70.25    70.1    70.1   71.39    71.9    73.1   73.16    74.3   74.04   74.01
    73.9      72      72      72   72.13    72.3   74.57    75.1   75.31   75.66
    75.8    75.5   75.57    75.6   74.96   74.51    73.8      74    74.8   75.07
    76.7    76.7    76.6    76.3    74.5    74.5    74.5   74.67    76.1   76.12
    76.3    76.7   76.66    76.4   76.46    76.8   76.95    77.5   77.45    77.2
    77.1
  3881.9  3890.9  3891.9  3900.9  3901.9  3910.9  3911.9  3950.9  3951.9  4000.9
  4001.9  4020.9  4031.9  4140.9  4151.9  4190.9  4191.9  4261.9  4411.9  4430.9
  4461.9  4480.9  4490.9  4491.9  4501.9    4521  4521.9  4550.9  4641.9  4740.9
  4761.9  4780.9  4860.9  4883.2  4885.9  4903.1  4933.2  4939.6  4943.2  4952.1
  4953.2 4957.69  4957.8 4957.91    4958 4958.11  4958.2  4985.5  4986.6  4986.7
  4998.3  5003.6  5013.2  5013.3    5019  5025.3 5057.36 5057.47 5057.58 5057.69
  5057.8  5059.4  5063.2  5073.2  5074.1  5103.2  5113.2  5134.1  5153.2  5184.3
  5206.2  5211.9  5241.9  5256.2  5261.9  5271.9  5276.2  5361.9    5375  5376.2
  5381.9  5411.9  5416.2  5441.9  5446.2  5451.9  5476.2  5481.9  5506.2  5546.2
  5561.9  5591.9  5606.2  5611.9  5626.2  5636.2  5651.9  5701.9  5721.9  5726.2
  5751.9  5756.2  5871.9  5876.2  5901.9  5906.2  5931.9  5936.2  5971.9  5986.2
  6101.9  6131.9  6136.2  6161.9  6166.2  6191.9  6196.2  6211.9  6216.2  6237.5
  6239.7
    82.5    79.4   79.14    76.8   76.62   75.07   74.96    73.5   73.51    74.2
   74.17   73.73   73.53    73.8   73.49   72.43   72.41   73.91   73.51    73.6
   72.51   71.81   71.45   71.43   71.68   72.75   72.81    72.9   72.31    71.6
   70.44   69.84      70      70      70    69.8    69.8   69.77   69.79   69.85
   69.41   70.31   73.11   73.11   73.11   73.11   73.11   73.31   73.32   73.32
    73.4   73.44    73.5    73.5   73.53   73.57   73.75   73.75   70.95   70.93
    70.9   70.65   70.62   70.52   70.52   70.25   70.16   69.97    70.3   70.84
   70.26   70.11   70.23    71.4   71.91   73.11   73.17   74.31   74.05   74.02
   73.91   72.01   72.01   72.01   72.14   72.55    74.9   75.11    75.6   75.67
   75.81   75.63    75.7   75.61   74.97   74.52   73.93   74.05   74.81   75.08
   76.71   76.71   76.61    76.5   74.87    74.6   74.51   74.68   76.11   76.13
   76.52   76.71    76.7   76.41   76.47   76.81   76.96   77.51    77.5   77.21
    77.1
                                                                                
                                                                                
                                                                                
                                                                                
                                           67.45   68.21   68.41   68.42   68.42
    68.5   68.54    68.6    68.6   68.63   68.67   68.85   68.85
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
        
Pier Skew, UpSta & Num, DnSta & Num=  ,4990.5, 2 ,4990.5, 2 , 0 , 0 , 0 ,,
       1       1
   52.24   69.45
       1       1
    52.2   69.41
Pier Skew, UpSta & Num, DnSta & Num=  ,5025.3, 2 ,5025.3, 2 , 0 , 0 , 0 ,,
       1       1
   55.22   69.69
       1       1
   55.18   69.65
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=82.53
