HEC-RAS study E117_baker.prj: E117-00-00

--- E117_baker.g02 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,17414   ,635.3,641,644.4
BEGIN DESCRIPTION:
Alamo - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
      3074725.94      13877272.1      3074732.35      13877032.2
      3074775.98     13875399.04       3074332.5     13873927.52
#Sta/Elev= 30
  2746.2      88  2986.2   84.14  3196.2   83.89  3236.2   85.92  3536.2   84.36
  3596.2   87.32  3696.2   85.17  4226.2   86.89  4316.2   84.38  4536.2   84.33
  4586.2   89.46    4620    89.7    4710   89.72    4760   85.76    4810   85.46
    4880   87.15    4920   84.71  4962.9   75.61  4987.4   73.77  5000.7    68.3
  5004.5   68.88  5010.7   74.82  5037.7    77.3    5057   84.92    5120   85.55
    5510   86.73    6030   86.74    6110   84.51    6140   86.02  6156.9   90.66
#Mann= 7 ,-1 , 0
  2746.2     .99       0  4316.2     .08       0    4810     .05       0
    4920     .04       0    5057     .04       0    5120     .08       0
    5510     .99       0
Bank Sta=4920,5057
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,16773   ,612.6,633,648.8
BEGIN DESCRIPTION:
Cross Section XS12
Offline detention ponds on left and right  overbanks.
Located At: US HOLLISTER
END DESCRIPTION:
XS GIS Cut Line= 4
      3075322.95     13877363.74      3075378.07     13875288.32
      3075218.87     13874595.64      3074957.69      13873529.8
#Sta/Elev= 30
    2456      88  2991.6    84.9  3421.6      87  3501.6    84.5    3590   86.76
  4662.2    85.8  4772.2    75.9  4822.2    74.1  4856.8   76.04  4903.4   85.66
  4943.6   82.29  4989.8   72.56  4995.2   67.52    5000   67.42  5010.7   72.64
  5029.9   73.87  5064.6   84.18    5082   84.08    5102   87.43  5128.6   77.41
  5152.2    71.8  5262.9    71.6  5312.9    80.9  5332.9    83.9  5372.9    84.8
    6060    86.3  6132.9    83.3  6302.9    84.1  6312.9    85.4  6340.3    97.4
#Mann= 7 ,-1 , 0
    2456     .99       0    3590     .08       0  4662.2     .05       0
  4943.6     .04       0  5064.6     .05       0  5312.9     .08       0
    6060     .99       0
#Block Obstruct= 2 ,-1
 4664.35 4903.45   85.52 5101.94 5411.71   85.02
Bank Sta=4943.6,5064.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,16140   ,325.1,359,348
BEGIN DESCRIPTION:
Hollister - 4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 6
       3075686.4      13877992.8      3075861.83     13875289.09
      3075890.78     13874895.12      3075934.96      13874434.3
      3075746.59     13873154.79      3075726.42      13873006.3
#Sta/Elev= 30
  1894.7   86.24  2054.7   84.85  2144.7   87.68  2384.7   88.13  2504.7   85.63
  2554.7   88.67  2964.7   87.98  3114.7   85.13  3474.7   87.02  3514.7   84.29
  3884.7   86.66    4440   85.14  4754.1   85.39  4943.6   81.68  4989.8   71.95
  4995.2   66.91    5000   66.81  5010.7   72.03  5029.9   73.26  5049.1   78.86
  5089.1   82.46    5800   84.94  6162.1   81.83  6312.1   85.91  6602.1   86.17
  6785.4      83  6815.4   88.29  6835.4   99.42  6855.4  104.55  6905.2  107.59
#Mann= 6 ,-1 , 0
  1894.7     .99       0  3884.7     .08       0    4440     .05       0
  4943.6     .04       0  5089.1     .08       0    5800     .99       0
Bank Sta=4943.6,5089.1
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,15781   ,146.1,162,165.3
BEGIN DESCRIPTION:
Hollister - 3
END DESCRIPTION:
XS GIS Cut Line= 5
      3075843.2913877960.2158332       3076011.2     13875323.92
      3076162.04     13874786.91      3076272.08     13874443.05
      3076063.18     13872851.89
#Sta/Elev= 30
1220.961   88.041292.733   86.211547.291   87.811653.357   85.511681.641   88.21
 1738.21   88.712098.834   86.112360.464   87.112395.819   84.412473.601   87.01
2916.815    85.6 3429.68   84.873462.914   84.253496.714   73.653528.251   71.96
3529.665   67.91 3538.08   66.463544.302   70.623565.728   72.363609.992   83.12
 3626.68   83.033739.181   83.714078.592   80.714113.947   83.714262.439   82.31
4425.074   86.214842.267   82.614856.409   83.61 4863.48   86.61 4873.38   95.41
#Mann= 5 ,-1 , 0
1220.961     .99       02916.815     .05       0 3429.68     .04       0
 3626.68     .08       03739.181     .99       0
#XS Ineff= 2 , 0
       0 3471.59   85.033607.072       0   83.17
Permanent Ineff=
       F       F
Bank Sta=3462.914,3609.992
XS Rating Curve= 0
Skew Angle= 45
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,15698   ,,,
BEGIN DESCRIPTION:
HOLLISTER; Circular columns
Structure ID: E117-00-00-09
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,146,2.6,45, 35, 35, , , .95, 0, ,,,
 3351.053394.6083409.3863410.518 3446.583462.9143470.8273470.9043607.2343607.312
3609.9923679.5723710.8253739.1813845.247 3866.464078.5924113.9474234.1554262.439
4297.7954311.9374425.0744453.3584573.5664672.5624693.775 4792.774842.2674849.338
4856.409 4863.484870.5514873.9454959.223
   85.31    84.9   84.96   84.97   85.17   85.27   85.31    88.4    87.9   84.25
   84.19   82.73   82.96   83.71   83.81   82.71   82.22   83.71   83.51   82.31
   82.81   82.71   86.21   85.21   83.31   83.91   84.21   83.71   82.86   82.84
   83.61   86.61   92.71   95.41     100
    85.3   83.94   83.56   84.97   84.76   84.24   81.76    82.5      82   82.46
   83.11   82.73   82.95    83.7    83.8    82.7    80.7    83.7    83.5    82.3
    82.8    82.7    86.2    85.2    83.3    83.9    84.2    83.7    82.6    82.7
    83.6    86.6    92.7    95.4     100
 3351.053394.6083409.3863410.518 3446.583462.9143470.8273470.9043607.2343607.312
3609.9923679.5723710.8253739.1813845.247 3866.464078.5924113.9474234.1554262.439
4297.7954311.9374425.0744453.3584573.5664672.5624693.775 4792.774842.2674849.338
4856.409 4863.484870.5514873.9454959.223
   85.31    84.9   84.96   84.97   85.17   85.27   85.31    88.4    87.9   84.25
   84.19   82.73   82.96   83.71   83.81   82.71   82.22   83.71   83.51   82.31
   82.81   82.71   86.21   85.21   83.31   83.91   84.21   83.71   82.86   82.84
   83.61   86.61   92.71   95.41     100
    85.3   83.94   83.56   84.97   84.76   84.24   81.76    82.5      82   82.46
   83.11   82.73   82.95    83.7    83.8    82.7    80.7    83.7    83.5    82.3
    82.8    82.7    86.2    85.2    83.3    83.9    84.2    83.7    82.6    82.7
    83.6    86.6    92.7    95.4     100
Pier Skew, UpSta & Num, DnSta & Num=  ,3516.23, 2 ,3516.23, 2 , 0 , 0 , 0 ,,
       2       2
   71.25   83.33
       2       2
   71.42    83.5
Pier Skew, UpSta & Num, DnSta & Num=  ,3565.728, 2 ,3565.728, 2 , 0 , 0 , 0 ,,
       2       2
   71.31   83.15
       2       2
   71.48   83.32
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,-1,1.25,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=95.41

Type RM Length L Ch R = 1 ,15619   ,343.8,255,180.3
BEGIN DESCRIPTION:
Hollister - 2
END DESCRIPTION:
XS GIS Cut Line= 5
      3075981.4513877888.3586389      3076149.23     13875254.07
      3076299.91     13874717.65      3076410.26     13874372.81
      3076201.22     13872780.54
#Sta/Elev= 30
1220.961   88.191292.733   86.361547.291   87.961653.357   85.66 1738.21   88.86
2098.834   86.262360.464   87.262395.819   84.562473.601   87.162861.449   85.49
3118.906   85.11 3429.68   85.023462.914    84.43496.714    73.83528.251   72.11
3529.665   68.06 3538.08   66.613544.302   70.773565.728   72.513609.992   83.27
 3626.68   83.18 3866.46   82.864078.592   80.864113.947   83.864262.439   82.46
4425.074   86.364842.267   82.764856.409   83.76 4863.48   86.764873.097   95.56
#Mann= 6 ,-1 , 0
1220.961     .99       02861.449     .08       03118.906     .05       0
 3429.68     .04       0 3626.68     .08       0 3866.46     .99       0
#XS Ineff= 2 , 0
       0 3471.59      843607.072       0   83.27
Permanent Ineff=
       F       F
Bank Sta=3462.914,3609.992
XS Rating Curve= 0
Skew Angle= 45
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,15364   ,321.3,363,378.5
BEGIN DESCRIPTION:
Hollister - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 6
       3076583.6       13877942.      3076603.97     13875005.64
      3076593.13     13874627.62      3076527.79     13874474.54
      3076321.22     13872769.93      3076313.03     13872626.04
#Sta/Elev= 30
  1600.4   86.96  2500.4   86.31  2550.4   84.65  2590.4   90.58  2660.4   92.01
  2730.4    84.5  2760.4   87.28  2830.4   88.29  3070.4   83.54  4050.4   81.98
  4450.4   84.29  4530.4   81.73  4877.8   81.72 4930.34   81.73 4983.04   70.11
 4990.39   66.44 5010.16   67.13 5014.22   67.99 5017.13   71.52  5082.4   83.54
  5162.4   85.18  5600.5   82.45  5640.5   83.93  5870.5   82.22  5990.5    84.1
  6799.5    82.7  6829.5    84.6  6849.5   94.45  6869.5  100.36  6943.6   102.3
#Mann= 6 ,-1 , 0
  1600.4     .99       0  4050.4     .08       0  4877.8     .05       0
 4930.34     .04       0  5082.4     .08       0  5600.5     .99       0
Bank Sta=4930.34,5082.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,15001   ,331.8,292,232.4
BEGIN DESCRIPTION:
PL1_E117-00-00-8a-4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 5
      3076977.87       13878372.      3076920.42      13874704.5
      3076884.69     13874250.24      3076613.62      13872665.6
      3076584.31     13872498.52
#Sta/Elev= 30
  1076.4   86.37  1136.4   88.48  1186.4   86.27  1856.4    86.4  2726.4   84.03
  2756.4   82.14  2786.4   84.64  3026.4   85.54  3256.4   83.13  3926.4   83.12
  4596.4   81.13  4646.4   82.71  4854.7   80.36  4914.7   80.15  4944.7   77.18
 4983.04   69.88 4990.39   66.21 5010.16    66.9 5014.22   67.76 5017.13   71.29
 5075.73    81.2  5124.7   84.21  5360.4   83.04  5450.4   84.76  5750.4   81.88
  5870.4   84.27    6878   83.36    6908   86.34    6948   96.75  6977.7   97.26
#Mann= 6 ,-1 , 0
  1076.4     .99       0  3926.4     .08       0  4854.7     .05       0
  4914.7     .04       0 5075.73     .08       0  5870.4     .99       0
Bank Sta=4914.7,5075.73
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,14709   ,20.5,28,19.4
BEGIN DESCRIPTION:
PL1_E117-00-00-8a-3
END DESCRIPTION:
XS GIS Cut Line= 5
 3077295.223850613878551.7563825      3077372.38     13874780.97
      3077108.36     13874400.77 3076887.380757613872454.0443065
 3076880.356065113872392.1599901
#Sta/Elev= 30
 686.682   89.11  824.57   84.011077.365   86.711108.007   85.41 1169.29   87.01
1437.482   86.61 2999.83   84.013224.817   83.013421.461   82.513459.763   80.91
3567.009   81.013760.558   81.313813.262   69.693820.616   66.02 3840.38   66.71
 3844.44   67.573847.351    71.13905.952   81.013962.748   82.714259.285   82.71
4496.834   83.214565.778   81.914596.343   83.314665.364   82.714895.102   84.81
5124.914   82.115339.406   83.315431.408   82.41 5461.97    83.9 5493.69    90.8
#Mann= 11 ,-1 , 0
 686.682     .99       01437.482     .08       0 2999.83     .08       0
3224.817     .05       03421.461     .08       03567.009     .05       0
3760.558     .04       03905.952     .05       03962.748     .08       0
4259.285     .05       04895.102     .99       0
#XS Ineff= 2 , 0
       0 3773.96    78.6 3892.62       0    78.6
Permanent Ineff=
       F       F
Bank Sta=3760.558,3905.952
XS Rating Curve= 0
Skew Angle= 40
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,14698.5 ,,,
BEGIN DESCRIPTION:
PL1_E117-00-00-8a
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,1,2.6,40, 19, 19, , , .95, 0, ,,,
 3772.75 3774.04 3779.51 3799.17 3802.54 3813.26 3816.02 3818.09 3820.62 3834.48
 3837.62 3840.38 3844.44 3847.35 3855.93 3889.86 3889.943890.021  3893.8
   78.51   78.51   78.51   78.52   78.52   78.53   78.53   78.53   78.54   78.55
   78.55   78.55   78.55   78.56   78.56   78.59   78.59   78.59   78.59
   77.51   77.51   77.51   77.52   77.52   77.53   77.53   77.53   77.54   77.55
   77.55   77.55   77.55   77.56   77.56   77.56   77.56   77.56   77.56
 3772.75 3774.04 3779.51 3799.17 3802.54 3813.26 3816.02 3818.09 3820.62 3834.48
 3837.62 3840.38 3844.44 3847.35 3855.93 3889.86 3889.943890.021  3893.8
   78.51   78.51   78.51   78.52   78.52   78.53   78.53   78.53   78.54   78.55
   78.55   78.55   78.55   78.56   78.56   78.59   78.59   78.59   78.59
   77.51   77.51   77.51   77.52   77.52   77.53   77.53   77.53   77.54   77.55
   77.55   77.55   77.55   77.56   77.56   77.56   77.56   77.56   77.56
Pier Skew, UpSta & Num, DnSta & Num=  ,3818.119, 2 ,3818.119, 2 , 0 , 0 , 0 ,,
      .7      .7
   65.58   78.53
      .7      .7
   65.58   78.53
Pier Skew, UpSta & Num, DnSta & Num=  ,3837.653, 2 ,3837.653, 2 , 0 , 0 , 0 ,,
      .7      .7
   65.29   78.55
      .7      .7
   65.29   78.55
Pier Skew, UpSta & Num, DnSta & Num=  ,3855.961, 2 ,3855.961, 2 , 0 , 0 , 0 ,,
      .7      .7
   70.85   78.56
      .7      .7
   70.85   78.56
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,-1,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 129
  487.51    86.3  487.59    86.3  502.83    86.9  502.91    86.9  617.74    87.8
  617.82    87.8  686.68    89.1  686.76    89.1  747.97      86  748.04      86
  801.59    85.4  801.67    85.4  816.91    84.7  816.99   84.69  824.57      84
  824.65      84  870.53    85.2  870.61    85.2   954.8    85.5  954.87    85.5
  970.12    85.4   970.2    85.4  985.44    86.2  985.52    86.2 1077.37    86.7
 1077.44    86.7 1108.01    85.4 1108.08    85.4 1130.99    85.5 1131.07    85.5
 1169.29      87 1169.37      87 1437.41    86.6 1437.48    86.6 2999.83      84
 3000.14      84 3000.21      84 3015.46    83.6 3015.53    83.6 3107.38    83.3
 3107.46    83.3 3224.82      83 3421.46    82.5 3421.54    82.5 3459.76    80.9
 3459.84    80.9 3567.01      81 3567.09      81 3589.99    80.7 3590.07    80.7
 3648.67    81.8 3648.75    81.8 3725.27    81.9 3725.35    81.9 3737.81   81.56
 3748.26   81.44 3760.56    81.33771.311   78.833773.889   78.24 3773.97   78.22
 3774.04    78.2 3779.51   76.95 3799.17   72.43 3802.54   71.66 3813.26   69.68
 3816.02    67.5 3818.09   66.65 3820.62   66.01 3834.48   66.14 3837.62    66.3
 3840.38    66.7 3844.44   67.56 3847.35   71.09 3855.93   71.87 3889.86   78.06
 3889.94   78.083890.021   78.093905.949      813927.361   81.64 3962.75    82.7
 3962.82    82.7 3983.51    83.2 3983.58    83.24205.661    83.3 4205.74    83.3
4228.641    82.2 4228.72    82.2 4259.28    82.7 4259.36    82.7 4268.09   82.72
 4496.68    83.2 4496.76    83.2 4496.83    83.2 4519.74    82.2 4519.82    82.2
 4550.38    82.7 4550.46    82.7  4565.7    81.9 4565.78    81.9 4596.34    83.3
 4596.42    83.34665.291    82.7 4665.36    82.7 4703.59    83.8 4703.67    83.8
 4795.52    83.6 4795.59    83.6  4895.1    84.8 4895.18    84.8 5086.61    82.9
 5086.69    82.9 5124.91    82.15124.991    82.1 5339.41    83.35339.479    83.3
 5377.71    82.4 5377.79    82.45408.351    83.1 5408.43    83.1 5431.33    82.4
 5431.41    82.45461.971    83.9 5462.05   83.92 5477.29    87.5 5477.37   87.52
 5484.96   89.68 5485.03    89.75493.609    90.8 5493.69    90.8
BR U #Mann= 11
  487.51     .99 1437.48     .08 2999.83     .08 3224.82     .05 3421.46     .08
 3567.01     .05 3760.56     .043905.949     .05 3962.75     .08 4259.28     .05
  4895.1     .99
BR U Banks=3760.56,3905.949
BR D #Sta/Elev= 129
  487.51    86.3  487.59    86.3  502.83    86.9  502.91    86.9  617.74    87.8
  617.82    87.8  686.68    89.1  686.76    89.1  747.97      86  748.04      86
  801.59    85.4  801.67    85.4  816.91    84.7  816.99   84.69  824.57      84
  824.65      84  870.53    85.2  870.61    85.2   954.8    85.5  954.87    85.5
  970.12    85.4   970.2    85.4  985.44    86.2  985.52    86.2 1077.37    86.7
 1077.44    86.7 1108.01    85.4 1108.08    85.4 1130.99    85.5 1131.07    85.5
 1169.29      87 1169.37      87 1437.41    86.6 1437.48    86.6 2999.83      84
 3000.14      84 3000.21      84 3015.46    83.6 3015.53    83.6 3107.38    83.3
 3107.46    83.3 3224.82      83 3421.46    82.5 3421.54    82.5 3459.76    80.9
 3459.84    80.9 3567.01      81 3567.09      81 3589.99    80.7 3590.07    80.7
 3648.67    81.8 3648.75    81.8 3725.27    81.9 3725.35    81.9 3737.81   81.56
 3748.26   81.44 3760.56    81.33771.311   78.833773.889   78.24 3773.97   78.22
 3774.04    78.2 3779.51   76.95 3799.17   72.43 3802.54   71.66 3813.26   69.68
 3816.02    67.5 3818.09   66.65 3820.62   66.01 3834.48   66.14 3837.62    66.3
 3840.38    66.7 3844.44   67.56 3847.35   71.09 3855.93   71.87 3889.86   78.06
 3889.94   78.083890.021   78.093905.949      813927.361   81.64 3962.75    82.7
 3962.82    82.7 3983.51    83.2 3983.58    83.24205.661    83.3 4205.74    83.3
4228.641    82.2 4228.72    82.2 4259.28    82.7 4259.36    82.7 4268.09   82.72
 4496.68    83.2 4496.76    83.2 4496.83    83.2 4519.74    82.2 4519.82    82.2
 4550.38    82.7 4550.46    82.7  4565.7    81.9 4565.78    81.9 4596.34    83.3
 4596.42    83.34665.291    82.7 4665.36    82.7 4703.59    83.8 4703.67    83.8
 4795.52    83.6 4795.59    83.6  4895.1    84.8 4895.18    84.8 5086.61    82.9
 5086.69    82.9 5124.91    82.15124.991    82.1 5339.41    83.35339.479    83.3
 5377.71    82.4 5377.79    82.45408.351    83.1 5408.43    83.1 5431.33    82.4
 5431.41    82.45461.971    83.9 5462.05   83.92 5477.29    87.5 5477.37   87.52
 5484.96   89.68 5485.03    89.75493.609    90.8 5493.69    90.8
BR D #Mann= 11
  487.51     .99 1437.48     .08 2999.83     .08 3224.82     .05 3421.46     .08
 3567.01     .07 3760.56     .043905.949     .053927.361     .08 4228.72     .05
  4895.1     .99
BR D Banks=3760.56,3905.949
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=89.11

Type RM Length L Ch R = 1 ,14681   ,464.6,525,590.8
BEGIN DESCRIPTION:
PL1_E117-00-00-8a-2
END DESCRIPTION:
XS GIS Cut Line= 5
 3077319.269911713878560.9554988      3077396.54     13874784.44
      3077132.31     13874403.95 3076912.000898913872463.1445085
 3076904.976147213872401.2601988
#Sta/Elev= 30
 686.682   89.11  824.57   84.011077.365   86.711108.007   85.41 1169.29   87.01
1437.482   86.61 2999.83   84.013224.817   83.013421.461   82.513459.763   80.91
3567.009   81.013760.558   81.313813.262   69.693820.616   66.02 3840.38   66.71
 3844.44   67.573847.351    71.13905.952   81.013927.356   81.653983.509   83.21
4205.737   83.314228.719   82.214496.834   83.214565.778   81.914596.343   83.31
4895.102   84.815124.914   82.115431.408   82.41 5461.97    83.9 5493.69    90.8
#Mann= 11 ,-1 , 0
 686.682     .99       01437.482     .08       0 2999.83     .08       0
3224.817     .05       03421.461     .08       03567.009     .07       0
3760.558     .04       03905.952     .05       03927.356     .08       0
4228.719     .05       04895.102     .99       0
#XS Ineff= 2 , 0
       0 3773.96    78.6 3892.62       0    78.6
Permanent Ineff=
       F       F
Bank Sta=3760.558,3905.952
XS Rating Curve= 0
Skew Angle= 40
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,14156   ,71.5,73,71.2
BEGIN DESCRIPTION:
Langfield - 3
Right side spills to E115-04-00
END DESCRIPTION:
XS GIS Cut Line= 5
      3077538.9813878773.2714025      3077706.91     13875145.11
      3077729.12     13874512.11      3077749.93     13873826.31
      3077433.41     13872043.25
#Sta/Elev= 30
   736.2   87.29  1096.2   85.99  1186.2   88.09  1216.2   86.29  1456.2   85.39
  1576.2   86.69  3966.2   82.59  4953.8   82.37    4987   71.08  4992.1   66.84
  4996.7   66.74  5007.9   66.97  5011.1   69.16  5053.8   81.14  5058.5   81.18
  5158.9   83.05  5689.1   83.89  5999.1   82.39  6089.1   80.79  6129.1   83.09
  6449.1   81.89  6489.1   80.99  6519.1   77.39  6619.1   78.29  6649.1   82.99
  6669.1   83.79  7029.1   82.79  7259.1   84.99  7399.1   80.79  7498.7   83.19
#Mann= 5 ,-1 , 0
   736.2     .99       0  3966.2     .08       0  4953.8     .04       0
  5058.5     .08       0  5999.1     .99       0
#XS Ineff= 2 , 0
       0 4966.23   82.91 5057.23       0   83.07
Permanent Ineff=
       F       F
Bank Sta=4953.8,5053.8
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,14121.5 ,,,
BEGIN DESCRIPTION:
LANGFIELD
Structure ID: E117-00-00-8
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,49,2.6,0, 147, 147, , , .95, 0, ,,,
   736.2   776.3   916.2   956.2   956.3   986.3   996.2  1036.3  1056.3  1096.2
  1126.3  1146.3  1186.2  1206.3  1216.2  1426.2  1456.2  1506.2  1536.2  1546.3
  1576.2  1606.3  1806.3  1836.3  1866.3  1926.3  2136.3  2336.3  2476.3  2506.3
  2516.3  2526.3  2546.3  2556.3  2566.3  2646.3  2656.3  2666.3  2696.3  2746.3
  2766.3  2796.3  2816.3  2846.3  2886.3  2906.3  2936.3  2946.3  2956.3  2976.3
  3036.3  3046.3  3066.3  3096.3  3166.3  3196.3  3216.3  3316.3  3446.3  3486.3
  3506.3  3516.3  3546.3  3566.3  3576.3    3610  3626.3  3686.3  3696.3  3706.3
  3716.3  3786.3  3906.3  3956.3  3966.2  3996.3  4016.3  4026.3  4056.2  4086.3
  4146.3  4177.7  4197.7  4227.7  4237.7  4247.7    4260  4267.7  4287.7  4296.2
  4327.7  4357.7  4387.7  4487.7  4567.7  4597.7  4617.7  4677.7  4697.7  4699.5
  4717.7  4737.7  4739.5  4747.7  4787.7  4837.7  4852.1  4862.8  4867.7  4907.7
  4916.3  4923.6  4953.8 4965.87 4965.98 4966.09 4966.21  4966.3  4981.9    4987
  4990.2  4990.3  4992.1  4996.7  4998.5  5007.9  5009.6  5009.7  5011.1  5025.9
  5027.3  5053.8 5056.79  5056.9 5057.01 5057.09  5057.2  5058.5  5107.1  5122.4
  5158.9  5239.8  5286.4  5632.9  5666.2  5686.2  5689.1
    87.3   87.22   86.91   87.41   87.41    86.8   86.72    86.4   86.05   86.01
   86.71   87.18   88.11    86.9   86.31   86.51   85.97   86.04   86.09    86.1
   86.71   86.66   86.32   86.26   86.21   86.11   85.75    85.4   85.17    85.5
    85.3   85.08    85.5    85.6   85.01    84.9    85.3    85.4   84.79    84.7
   84.67   84.62   84.58   84.53   84.46   84.43   84.38   84.36   84.34   84.31
   84.21   84.19   84.15    84.1   83.98   83.93    83.9   83.72    83.5   83.43
    83.4    83.5    84.4    83.9    84.2   83.53    83.2    84.3    84.2    83.5
    83.4    83.7    84.1   82.63   82.61   82.38   82.22   82.14    82.3    82.5
   82.32    82.7   82.56    82.7   82.74   82.79   82.84   82.88      83   83.01
   82.99   82.98   82.96   82.92   82.88   82.86   82.85   82.82   82.81   82.81
   82.26    81.7   81.84    82.5    82.6   81.95      82   82.92   82.89   82.66
   82.96   83.02   83.27   83.37   87.57   87.57   87.57   87.57   87.54   87.53
   87.52   87.52   87.52   87.51    87.5   87.48   87.48   87.48   87.48   87.44
   87.44   87.39   87.38   87.38   83.18   83.18   83.18   83.17   82.86   82.78
   83.07   83.18   83.24   83.71   83.83    83.9   83.89
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                    77.8   81.97   81.94   81.93
   81.92   81.92   81.92   81.91    81.9   81.88   81.88   81.88   81.88   81.84
   81.84   81.79   81.78   81.78   81.78   81.78   81.18
                                                        
   736.2   776.3   916.2   956.2   956.3   986.3   996.2  1036.3  1056.3  1096.2
  1126.3  1146.3  1186.2  1206.3  1216.2  1426.2  1456.2  1506.2  1536.2  1546.3
  1576.2  1606.3  1806.3  1836.3  1866.3  1926.3  2136.3  2336.3  2476.3  2506.3
  2516.3  2526.3  2546.3  2556.3  2566.3  2646.3  2656.3  2666.3  2696.3  2746.3
  2766.3  2796.3  2816.3  2846.3  2886.3  2906.3  2936.3  2946.3  2956.3  2976.3
  3036.3  3046.3  3066.3  3096.3  3166.3  3196.3  3216.3  3316.3  3446.3  3486.3
  3506.3  3516.3  3546.3  3566.3  3576.3    3610  3626.3  3686.3  3696.3  3706.3
  3716.3  3786.3  3906.3  3956.3  3966.2  3996.3  4016.3  4026.3  4056.2  4086.3
  4146.3  4177.7  4197.7  4227.7  4237.7  4247.7    4260  4267.7  4287.7  4296.2
  4327.7  4357.7  4387.7  4487.7  4567.7  4597.7  4617.7  4677.7  4697.7  4699.5
  4717.7  4737.7  4739.5  4747.7  4787.7  4837.7  4852.1  4862.8  4867.7  4907.7
  4916.3  4923.6  4953.8 4965.87 4965.98 4966.09 4966.21  4966.3  4981.9    4987
  4990.2  4990.3  4992.1  4996.7  4998.5  5007.9  5009.6  5009.7  5011.1  5025.9
  5027.3  5053.8 5056.79  5056.9 5057.01 5057.09  5057.2  5058.5  5107.1  5122.4
  5158.9  5239.8  5286.4  5632.9  5666.2  5686.2  5689.1
    87.3   87.22   86.91   87.41   87.41    86.8   86.72    86.4   86.05   86.01
   86.71   87.18   88.11    86.9   86.31   86.51   85.97   86.04   86.09    86.1
   86.71   86.66   86.32   86.26   86.21   86.11   85.75    85.4   85.17    85.5
    85.3   85.08    85.5    85.6   85.01    84.9    85.3    85.4   84.79    84.7
   84.67   84.62   84.58   84.53   84.46   84.43   84.38   84.36   84.34   84.31
   84.21   84.19   84.15    84.1   83.98   83.93    83.9   83.72    83.5   83.43
    83.4    83.5    84.4    83.9    84.2   83.53    83.2    84.3    84.2    83.5
    83.4    83.7    84.1   82.63   82.61   82.38   82.22   82.14    82.3    82.5
   82.32    82.7   82.56    82.7   82.74   82.79   82.84   82.88      83   83.01
   82.99   82.98   82.96   82.92   82.88   82.86   82.85   82.82   82.81   82.81
   82.26    81.7   81.84    82.5    82.6   81.95      82   82.92   82.89   82.66
   82.96   83.02   83.27   83.37   87.57   87.57   87.57   87.57   87.54   87.53
   87.52   87.52   87.52   87.51    87.5   87.48   87.48   87.48   87.48   87.44
   87.44   87.39   87.38   87.38   83.18   83.18   83.18   83.17   82.86   82.78
   83.07   83.18   83.24   83.71   83.83    83.9   83.89
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                    77.8   81.97   81.94   81.93
   81.92   81.92   81.92   81.91    81.9   81.88   81.88   81.88   81.88   81.84
   81.84   81.79   81.78   81.78   81.78   81.78   81.18
                                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,4996.7, 2 ,4996.7, 2 , 0 , 0 , 0 ,,
     1.2     1.2
   65.76   82.91
     1.2     1.2
   65.61   82.76
Pier Skew, UpSta & Num, DnSta & Num=  ,5027.3, 2 ,5027.3, 2 , 0 , 0 , 0 ,,
     1.2     1.2
    71.5   82.84
     1.2     1.2
   71.35   82.69
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,-1,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=88.09

Type RM Length L Ch R = 1 ,14083   ,213.8,206,204.2
BEGIN DESCRIPTION:
Langfield - 2
Right side spills to E115-04-00
END DESCRIPTION:
XS GIS Cut Line= 5
      3077608.79     13878791.43      3077776.79     13875161.95
        3077799.     13874528.91      3077819.82     13873842.58
      3077503.21     13872059.01
#Sta/Elev= 30
   736.2   87.29  1096.2   85.99  1186.2   88.09  1216.2   86.29  1456.2   85.39
  1576.2   86.69  3966.2   82.59  4953.8   82.37    4987   70.91  4990.3   67.33
  4996.7   66.57  5007.9    66.8  5011.1   68.99  5053.8   81.14  5058.5   81.18
  5158.9   83.05  5689.1   83.89  5999.1   82.39  6089.1   80.79  6129.1   83.09
  6449.1   81.89  6489.1   80.99  6519.1   77.39  6619.1   78.29  6649.1   82.99
  6669.1   83.79  7029.1   82.79  7259.1   84.99  7399.1   80.79    7501   83.02
#Mann= 5 ,-1 , 0
   736.2     .99       0  3966.2     .08       0  4953.8     .04       0
  5058.5     .08       0  5999.1     .99       0
#XS Ineff= 2 , 0
       0 4966.23   81.82 5057.44       0   81.82
Permanent Ineff=
       F       F
Bank Sta=4953.8,5053.8
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,13877.0 ,230.8,297,319
BEGIN DESCRIPTION:
Langfield - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
       3077808.5       13878800.      3077976.62     13875170.08
      3078020.36     13873827.98      3077700.13     13872024.05
#Sta/Elev= 30
   693.7   86.22  1713.7   86.92  1953.7   84.44  2173.7   86.22  3463.7   83.74
  3703.7   85.76    4000   82.83  4728.2   80.68  4888.2   80.91  4938.2   82.83
  4955.8   81.12  4986.3   71.65  4993.7   66.34  4999.9   65.99  5006.2   66.47
  5009.5   69.77  5020.9   71.75  5046.9   82.87  5568.2   81.75    5701   83.98
    5931   83.83    6021   82.04    6391   84.13    6501   82.34    6571    84.8
    6701   82.23    6771   83.78    7061   81.54    7381   84.28  7503.1   81.94
#Mann= 5 ,-1 , 0
   693.7     .99       0    4000     .08       0  4938.2     .04       0
  5046.9     .08       0    6021     .99       0
Bank Sta=4938.2,5046.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,13580   ,1233,1104,1013.4
BEGIN DESCRIPTION:
Cross Section XS11
Right overbank spills to E115-04
Located At: DS LANGFIELD
END DESCRIPTION:
XS GIS Cut Line= 4
      3077985.75     13878594.91      3078204.66     13874754.84
      3078416.93     13874282.81      3078717.06     13872000.34
#Sta/Elev= 30
  1008.5      86  2567.8    84.9  3307.8    82.9  3827.8    84.4  3987.8    82.2
    4238    83.8  4437.8    80.4  4707.8    81.5  4777.8    79.6  4933.1   80.69
  4955.8   80.28  4986.3   70.81  4993.7    65.5  4999.9   65.15  5006.2   65.63
  5009.5   68.93  5020.9   70.91  5046.9   82.03    5080   82.08  5184.8    81.7
  5214.8    80.4  5264.8    81.9  5962.3    82.5  6002.3    81.6    6060   82.85
  6202.3    83.2  6302.3    81.7  6742.3    82.6  6972.3    81.3  7674.4    82.4
#Mann= 7 ,-1 , 0
  1008.5     .99       0    4238     .08       0  4933.1     .04       0
  4955.8     .04       0  5046.9     .04       0    5080     .08       0
    6060     .99       0
Bank Sta=4955.8,5046.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,12476   ,268.1,312,316.9
BEGIN DESCRIPTION:
Black Gum - 4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 6
       3079755.2       13876942.        3079558.     13875904.54
      3079339.21     13874813.94      3079196.13      13874578.5
      3079364.43     13872918.78      3079320.83     13872601.27
#Sta/Elev= 30
    2698   84.43    2878   82.89    3548   82.31  3844.1    82.8  3934.1   85.64
  3964.1   85.47  4004.1   82.74  4144.1   80.39  4254.1   82.41  4384.1   82.22
  4464.1   80.05  4534.1   82.29  4744.1   79.31  4916.5   79.72  4971.2   73.12
  4988.1   68.55  4990.4   67.13    4991   65.25  4998.6   65.09  5009.1   65.98
  5011.4   68.88  5031.1   74.17  5086.5   80.59    5422   79.36    5522   81.93
    6072   81.95    6272   81.51    6422   83.33  6970.2   81.83  7130.7   82.61
#Mann= 5 ,-1 , 0
    2698     .99       0  4004.1     .08       0  4916.5     .04       0
  5086.5     .08       0    6072     .99       0
Bank Sta=4916.5,5086.5
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,12164   ,26.1,26,26
BEGIN DESCRIPTION:
Black Gum - 3
Low points on right overbank are from street flow
END DESCRIPTION:
XS GIS Cut Line= 6
      3080049.9613876886.0687105      3079851.27     13875840.87
       3079549.5     13874606.18      3079508.12     13874476.15
       3079666.5     13872913.42 3079618.041715813872560.4680522
#Sta/Elev= 30
    2591   84.74  3377.1   81.76  3689.1    83.1  3726.2   80.89  4090.5    82.1
  4140.5    79.5  4380.5    80.7  4430.5    78.7    4600    81.1  4760.5    78.3
  4840.3   80.97  4934.6   80.02  4951.3   79.85  4994.9   65.07    5006   65.42
  5008.8   69.38  5019.1   70.61  5045.6   81.68  5113.6   81.17  5122.2   75.68
  5146.4      79  5246.4    78.7  5296.4    81.1  5766.4    82.7  5846.4    80.7
  6096.4    81.2  6656.9    82.9  6708.5   85.13  6848.5   81.03    6999   84.19
#Mann= 5 ,-1 , 0
    2591     .99       0  4090.5     .08       0  4934.6     .04       0
  5122.2     .08       0  5766.4     .99       0
#XS Ineff= 2 , 0
       0 4950.89   80.95  5044.2       0   81.69
Permanent Ineff=
       F       F
Bank Sta=4951.3,5045.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,12151   ,,,
BEGIN DESCRIPTION:
BLACK GUM BICYCLE BRIDGE
Structure ID: E117-00-00-07
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,6,2.6,0, 60, 60, , , .95, 0, ,,,
  3636.2  3690.5  3710.5  3720.5  3740.5  3750.5  3770.5  4090.5  4120.5  4140.5
  4160.5  4200.5  4380.5  4430.5  4436.2  4470.5  4490.5  4600.5  4660.5  4710.5
  4736.2  4760.5  4820.5  4840.3  4941.2 4950.99  4951.1  4951.4 4951.51  4951.6
 5043.69  5043.8 5043.91 5044.29  5044.4  5045.6  5113.6  5122.2  5146.4  5195.8
  5206.4  5246.4  5266.4  5296.4  5305.8  5766.4  5816.4  5846.4  5866.4  5896.4
  5905.8  6006.4  6036.4  6096.4  6125.8  6146.4  6496.4  6546.4    6655  6656.9
    82.9   83.11   81.81   80.81   81.11   82.01   82.61   82.11   81.01   79.69
   79.51   81.11   80.71   78.94   78.82   79.51   80.41   81.11   79.91   79.71
   78.55   78.62   80.01   80.98   79.96   81.75   86.55    86.6    86.6    86.6
   87.46   87.46   82.66   82.62   82.61   81.69   81.18   79.61   79.87    80.4
   80.14   78.71   79.09   81.11    81.3   82.71   81.81   80.81   81.26   82.31
    82.6   82.51    81.7   81.32    82.3   82.41   82.78   83.91   83.51    82.9
    82.9    83.1    81.8    80.8    81.1      82    82.6    82.1      81    79.5
    79.5    81.1    80.7    78.7   78.81    79.5    80.4    81.1    79.9    79.7
   78.54    78.3      80   80.97   79.95   79.85   79.85   79.82   79.78    80.8
   81.66   81.66   81.66   81.62   81.18   81.68   81.17   75.68      79   79.66
    79.8    78.7      79    81.1   81.13    82.7    81.8    80.7    81.1    82.3
   82.32    82.5    81.6    81.2   81.91    82.4    82.5    83.9    83.5    82.9
  3636.2  3640.5  3690.5  3710.5  3720.5  3740.5  3750.5  3770.5  4090.5  4120.5
  4146.2  4160.5  4200.5  4316.2  4380.5  4416.2  4436.2  4470.5  4490.5  4600.5
  4660.5  4710.5  4730.5  4736.2  4760.5  4820.5  4840.3  4941.2 4950.99  4951.1
  4951.4 4951.51  4951.6 5043.69  5043.8 5043.91 5044.29  5044.4  5044.5  5045.6
  5113.6  5122.2  5195.8  5246.4  5266.4  5296.4  5305.8  5766.4  5795.8  5846.4
  5905.8  5995.8  6035.8  6095.8  6125.8  6146.4  6496.4  6546.4    6655  6656.9
    82.9   83.11   83.11   81.81   80.81   81.11   82.01   82.61   82.11   81.01
   79.51   79.51   81.11    80.9   80.71    79.3   78.82   79.51   80.41   81.11
   79.91   79.71   78.61   78.55   78.62   80.01   80.98   79.96   81.75   86.55
    86.6    86.6    86.6   87.46   87.46   82.66   82.62   82.61   82.53   81.69
   81.18   79.61    80.4   78.71   79.09   81.11    81.3   82.71    82.3   80.81
    82.6    82.7    81.7    81.3    82.3   82.41   82.78   83.91   83.51    82.9
                                                                                
                                                                                
                                                                                
           79.78    80.8   81.66   81.66   81.66   81.62   81.18
                                                                                
                                                                                
Pier Skew, UpSta & Num, DnSta & Num=  ,4977.8, 2 ,4977.8, 2 , 0 , 0 , 0 ,,
       1       1
   68.94   82.05
       1       1
    68.6   81.71
Pier Skew, UpSta & Num, DnSta & Num=  ,5017.6, 2 ,5017.6, 2 , 0 , 0 , 0 ,,
       1       1
   69.51   82.42
       1       1
   69.17   82.08
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=85.13

Type RM Length L Ch R = 1 ,12138   ,342.2,381,390.3
BEGIN DESCRIPTION:
Black Gum - 2
Low points on right overbank are from street flow
END DESCRIPTION:
XS GIS Cut Line= 6
 3080088.664380713876877.5455425      3079873.07     13875823.23
      3079573.44     13874597.34      3079532.33     13874468.13
      3079690.37     13872908.78 3079636.938087913872540.1637086
#Sta/Elev= 30
    2591   84.74  3377.1   81.76  3689.1    83.1  3726.2   80.89  4090.5    82.1
  4140.5    79.5  4380.5    80.7  4430.5    78.7    4600    81.1  4760.5    78.3
  4840.3   80.97  4934.6   80.02  4951.3   79.85  4994.9   64.71    5006   65.06
  5008.8   69.02  5019.1   70.25  5045.6   81.68  5113.6   81.17  5122.2   75.68
  5146.4      79  5246.4    78.7  5296.4    81.1  5766.4    82.7  5846.4    80.7
  6096.4    81.2  6656.9    82.9  6708.5   85.13  6848.5   81.03  7004.6   84.19
#Mann= 5 ,-1 , 0
    2591     .99       0  4090.5     .08       0  4934.6     .04       0
  5122.2     .08       0  5766.4     .99       0
#XS Ineff= 2 , 0
       0 4950.78   80.96 5044.41       0   81.68
Permanent Ineff=
       F       F
Bank Sta=4951.3,5045.6
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,11757   ,700.3,661,622.8
BEGIN DESCRIPTION:
Black Gum - 1
Cross Section XS10
END DESCRIPTION:
XS GIS Cut Line= 6
      3080189.23      13876856.2      3080071.02     13875799.67
      3079925.19     13874668.26      3079925.19     13874377.78
      3079939.07     13874159.67      3079657.11      13872510.4
#Sta/Elev= 30
  2662.8   84.45  4162.2    82.2  4222.2    80.3  4262.2    82.3    4430    82.1
  4482.2    79.7  4542.2    81.2  4782.2    79.2  4937.6   80.77  4948.2   80.07
  4988.1   67.27  4990.4   65.85    4991   63.97  4998.6   63.81  5009.1    64.7
  5011.4    67.6  5052.6   80.87    5109   80.46  5203.5    80.8  5273.5    78.6
  5303.5    80.6  5373.5    81.3  5802.1      82  5842.1    80.3  5902.1    82.9
  6002.1    83.1  6192.1    81.2  6452.1    82.9    6862    81.4  7050.2   84.27
#Mann= 6 ,-1 , 0
  2662.8     .99       0    4430     .08       0  4937.6     .04       0
  5052.6     .04       0    5109     .08       0  6002.1     .99       0
Bank Sta=4937.6,5052.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,11096   ,735.6,725,677.6
BEGIN DESCRIPTION:
Cross Section XS09
Low points on left overbank is from a small unnamed tributary flowing into E117.  Flow increases at this section therefore the unnamed tributary is left as effective
Located At: US BINGLE
END DESCRIPTION:
XS GIS Cut Line= 4
      3080282.85     13875747.07      3080615.08     13874405.71
      3080326.55     13873974.45      3080442.82     13873237.44
#Sta/Elev= 30
  3413.3    83.7  3443.3    82.7  3573.3    83.3  3653.3    82.2  3823.3    75.2
  3893.3    76.6  3953.3    79.9  4013.3    81.6  4393.3    81.9  4473.3    80.7
  4940.3    81.3  4976.8   68.13  4988.6   66.41  4989.5   64.46  5000.4   63.61
  5009.1   63.68  5015.3   69.44    5049   80.66  5058.8   80.49  5091.5   79.94
  5245.2    81.7  5314.1    80.5  5524.1    82.1  5664.1    81.9  5734.1    82.4
  5754.1    81.2  5834.1      81  5994.1      83  6044.1    86.2  6060.2    85.9
#Mann= 6 ,-1 , 0
  3413.3     .99       0  4393.3     .12       0  4940.3     .04       0
    5049     .04       0  5058.8     .08       0  5664.1     .05       0
Bank Sta=4940.3,5049
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,10371   ,273.4,321,359
BEGIN DESCRIPTION:
Bingle - 4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
      3081208.23       13875052.      3081249.54     13874210.96
      3081099.81     13874081.89      3080404.69     13872986.88
#Sta/Elev= 30
  4069.2   82.05  4569.2   80.31  4589.2   79.51  4639.2   78.88  4729.2   81.76
  4769.2   80.74  4849.2   80.49  4899.2    81.3  4911.3   80.91  4931.3   78.67
 4942.62   69.81 4990.04   65.21 4992.03   64.01 5010.04   65.22 5021.53   67.53
 5038.69   73.18  5071.3   77.85    5109   79.52    5219   80.48    5719   81.71
    5749   80.71    5819   80.62    5879   83.22    6159   85.11    6219   84.82
    6279   86.09    6309   87.94    6339   88.59    6389   84.94    6406    84.5
#Mann= 6 ,-1 , 0
  4069.2     .99       0  4589.2     .12       0  4931.3     .04       0
  5071.3     .12       0    5219     .08       0    5749     .05       0
Bank Sta=4931.3,5071.3
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,10050   ,137.2,148,137.2
BEGIN DESCRIPTION:
Bingle - 3
No higher points on left overbank
END DESCRIPTION:
XS GIS Cut Line= 5
 3081247.413519213875053.5948718      3081282.91     13874167.83
      3081307.03     13873959.33      3081267.75     13873710.77
       3080422.7     13872952.09
#Sta/Elev= 30
2912.041   81.883011.627   81.983042.269   80.483325.705   80.283348.687   78.28
3371.668   78.483425.291   81.583517.216   79.883570.839   81.78  3578.5   81.78
3622.319   77.983652.959   77.983767.023   82.413772.769   69.983814.901   67.82
3822.255   64.183840.258   65.393843.015   68.223868.831   73.353893.191   80.71
4052.452   81.684182.373   80.274243.963   79.984282.265   82.384657.627   84.98
 4688.27   87.184749.552   88.784780.194   87.884804.171   84.974814.666   84.58
#Mann= 7 ,-1 , 0
2912.041     .99       03570.839     .12       0  3578.5     .05       0
3767.023     .04       03893.191     .08       04182.373     .08       0
4804.171      .2       0
#XS Ineff= 2 , 0
       0 3767.98   79.66    3890       0   79.66
Permanent Ineff=
       F       F
Bank Sta=3767.023,3893.191
XS Rating Curve= 0
Skew Angle= 40
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,9975    ,,,
BEGIN DESCRIPTION:
BINGLE; Circular columns; Deck length taken along stream length because this is a skewed section
Structure ID: E117-00-00-06
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,130,2.6,40, 69, 69, , , .95, 0, ,,,
 2778.83 2812.46 2855.43 2886.07 2896.72 2912.04    2978 3008.64 3011.63 3042.27
 3292.08 3315.06 3325.71 3338.04 3341.033348.6893371.669    3384 3399.323424.219
 3425.29 3437.63 3440.61 3517.22 3532.543544.871  3555.6 3563.26 3570.84  3578.5
 3591.68 3616.88 3622.32 3652.96 3684.44 3723.593729.101  3746.7 3746.79 3746.87
 3746.96 3747.033767.021 3768.07 3772.77 3772.85 3803.41  3814.9 3820.26 3822.26
 3840.26 3842.023843.021 3847.92 3851.75 3868.83 3868.91 3889.87 3889.95 3890.04
 3890.123890.199 3893.19 3899.553902.771 3902.84 3916.25 3954.55  3964.2
    80.4    80.8    81.3    82.2   82.15   82.09   81.98   82.01   82.01   80.51
   80.33   80.32   80.31   78.94   78.71   79.24   80.84    81.7    81.8   81.55
   81.61   81.69   81.71   81.66    81.9    82.1   81.21   81.51   81.81   81.81
   80.67    80.9      81   81.54   82.09   82.44   82.48   82.64   86.24   86.24
   86.24   86.24    86.2    86.2   86.18   86.18   86.12   86.09   86.08   86.07
   86.03   86.03   86.02   85.99   85.96   85.84   85.84   85.69   85.69   82.09
   82.09   82.09      82   81.81   81.72    81.2    81.3    81.2    81.2
                                                                                
                                                                                
                                                                                
                                                                                
                           80.14   80.17   80.17   80.11   80.08   80.07   80.06
   80.02   80.02   80.01   79.98   79.95   79.83   79.83   79.72
                                                                        
 2778.83 2812.46 2855.43 2886.07 2896.72 2912.04    2978 3008.64 3011.63 3042.27
 3292.08 3315.06 3325.71 3338.04 3341.033348.6893371.669    3384 3399.323424.219
 3425.29 3437.63 3440.61 3517.22 3532.543544.871  3555.6 3563.26 3570.84  3578.5
 3591.68 3616.88 3622.32 3652.96 3684.44 3723.593729.101  3746.7 3746.79 3746.87
 3746.96 3747.033767.021 3768.07 3772.77 3772.85 3803.41  3814.9 3820.26 3822.26
 3840.26 3842.023843.021 3847.92 3851.75 3868.83 3868.91 3889.87 3889.95 3890.04
 3890.123890.199 3893.19 3899.553902.771 3902.84 3916.25 3954.55  3964.2
    80.4    80.8    81.3    82.2   82.15   82.09   81.98   82.01   82.01   80.51
   80.33   80.32   80.31   78.94   78.71   79.24   80.84    81.7    81.8   81.55
   81.61   81.69   81.71   81.66    81.9    82.1   81.21   81.51   81.81   81.81
   80.67    80.9      81   81.54   82.09   82.44   82.48   82.64   86.24   86.24
   86.24   86.24    86.2    86.2   86.18   86.18   86.12   86.09   86.08   86.07
   86.03   86.03   86.02   85.99   85.96   85.84   85.84   85.69   85.69   82.09
   82.09   82.09      82   81.81   81.72    81.2    81.3    81.2    81.2
                                                                                
                                                                                
                                                                                
                                                                                
                           80.14   80.17   80.17   80.11   80.08   80.07   80.06
   80.02   80.02   80.01   79.98   79.95   79.83   79.83   79.72
                                                                        
Pier Skew, UpSta & Num, DnSta & Num=  ,3803.411, 2 ,3803.411, 2 , 0 , 0 , 0 ,,
       2       2
   66.21   81.11
       2       2
   66.21   81.11
Pier Skew, UpSta & Num, DnSta & Num=  ,3851.748, 2 ,3851.748, 2 , 0 , 0 , 0 ,,
       2       2
   66.85   80.96
       2       2
   66.85   80.96
Abutment Skew #Up #Dn= , 2 , 2
3746.8773772.845
   81.66   69.98
3746.8773772.845
   81.66   69.98
Abutment Skew #Up #Dn= , 2 , 2
3868.9073890.272
   73.38   79.79
3868.9073890.272
   73.38   79.79
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,.8,-1,1.25,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=88.78

Type RM Length L Ch R = 1 ,9902    ,108,108,100.6
BEGIN DESCRIPTION:
Bingle - 2
No higher points on left overbank
END DESCRIPTION:
XS GIS Cut Line= 5
 3081355.824844213874954.4705271      3081391.04     13874075.89
      3081415.21      13873866.9      3081375.55     13873615.91
      3080529.17     13872856.05
#Sta/Elev= 30
2912.041    81.73011.627    81.83042.269    80.33325.705    80.13348.687    78.1
3371.668    78.33425.291    81.43517.216    79.73570.839    81.6  3578.5    81.6
3622.319    77.83652.959    77.83767.023   82.233772.769    69.83814.901   67.64
3822.255      643840.258   65.213843.015   68.043868.831   73.173893.191   80.53
4052.452    81.54182.373   80.094243.963    79.84282.265    82.24657.627    84.8
 4688.27      874749.552    88.64780.194    87.74804.171   84.794812.751    84.4
#Mann= 7 ,-1 , 0
2912.041     .99       03570.839     .12       0  3578.5     .05       0
3767.023     .04       03893.191     .08       04182.373     .08       0
4804.171      .2       0
#XS Ineff= 2 , 0
       0 3767.98   77.77    3890       0   77.77
Permanent Ineff=
       F       F
Bank Sta=3767.023,3893.191
XS Rating Curve= 0
Skew Angle= 40
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,9794    ,82.2,100,102.9
BEGIN DESCRIPTION:
Bingle - 1
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 4
       3081459.8       13874958.      3081516.12      13873864.8
      3081468.78     13873565.22      3080739.59      13872910.5
#Sta/Elev= 30
  3743.1   80.85  4053.1   80.68  4133.1   81.67  4213.1   81.28  4243.1   82.28
    4580   83.68  4833.1    83.4  4867.9   81.58    4915   81.97  4940.8   81.18
  4969.3   70.07  4978.3      68  4991.3   63.69  5001.1   62.79  5007.9   63.78
  5010.2   66.81  5022.2   70.01  5047.7   81.66  5117.9   81.47  5141.2    80.6
  5261.2   80.32  5351.2   80.45  5371.2   81.07  5771.2   81.55  5811.2   83.19
  5851.2   82.67  5971.2   82.97  6021.2   83.73  6051.2   82.75  6121.2   82.33
#Mann= 5 ,-1 , 0
  3743.1     .99       0    4580     .08       0  4940.8     .04       0
  5047.7     .05       0  5371.2     .99       0
Bank Sta=4940.8,5047.7
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,9694    ,100.1,102,102.4
BEGIN DESCRIPTION:
Deihl - 4
Interpolated channel, LIDAR overbanks
END DESCRIPTION:
XS GIS Cut Line= 3
      3081571.72      13874878.3      3081587.48     13873587.66
      3081027.06     13872827.62
#Sta/Elev= 30
  3814.5   81.27  4204.5   81.64  4254.5   82.87    4580   84.14  4834.5    82.3
  4864.5    80.9  4914.5   81.27  4940.8   80.05  4969.3   68.94  4978.3   66.87
  4991.3   62.56  5001.1   61.66  5007.9   62.65  5010.2   65.68  5022.2   68.88
  5047.7   80.53  5064.5   81.72  5105.3   81.32  5145.3   80.15  5185.3   80.42
  5215.3   79.61    5245    80.3  5275.3   81.01    5360   80.85  5495.3    80.6
  5565.3   79.76  5625.3   82.17  5775.3   82.12  5825.3   80.71  6049.6   81.91
#Mann= 6 ,-1 , 0
  3814.5     .99       0    4580     .08       0  4940.8     .04       0
  5047.7     .05       0    5245     .08       0    5360     .99       0
Bank Sta=4940.8,5047.7
XS Rating Curve= 0
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,9592    ,48,49,47.8
BEGIN DESCRIPTION:
Deihl - 3
END DESCRIPTION:
XS GIS Cut Line= 4
      3081672.15      13874853.4       3081680.6     13873823.36
      3081689.98     13873629.34      3081108.99     13872798.95
#Sta/Elev= 30
  3844.6   81.93    4211   81.89    4281   82.99    4451   81.09    4491   79.39
    4531   80.99    4551   79.89    4581   81.39    4641   80.59    4671   81.89
    4811   81.79    4915   79.69  4940.7    78.9  4969.3   67.79  4991.3   61.41
  5001.1   60.51  5007.9    61.5  5010.2   64.53  5022.2   67.73  5047.7   79.38
  5060.8   79.16  5131.6   77.98  5139.7   80.19    5235   79.57  5359.7   81.49
  5689.7   79.99  5739.7   81.79  5849.7   82.39  5939.7   81.29  6083.2   81.99
#Mann= 6 ,-1 , 0
  3844.6     .99       0    4671     .08       0    4915     .04       0
  5060.8     .05       0    5235     .08       0  5359.7     .99       0
#XS Ineff= 2 , 0
       0 4948.55   76.18 5039.44       0   76.18
Permanent Ineff=
       F       F
Bank Sta=4940.7,5047.7
XS Rating Curve= 0
Exp/Cntr=.5,.3
